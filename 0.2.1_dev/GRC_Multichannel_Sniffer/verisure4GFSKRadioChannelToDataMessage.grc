options:
  parameters:
    author: Francisco Nicolás Pérez Fernández
    category: '[Verisure GRC Hier Blocks]'
    generate_options: hb
    id: verisure4GFSKRadioChannelToDataMessage
    output_language: python
    title: Verisure 4GFSK Radio Channel to Data Mesagge
  states: {}

blocks:
- name: compensation_delay_time
  id: variable
  parameters:
    value: '2.1e-3'
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    comment: '@ -6 dB'
    value: (passband_end+stopband_start)/2
  states: {}
- name: decimation
  id: variable
  parameters:
    value: int(samp_rate/samp_rate_demod)
  states: {}
- name: filterGain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fourPamConstellation
  id: variable_constellation
  parameters:
    comment: Verisure 4GFSK Constellation
    const_points: '[-1/3,-1,1/3,1]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: '[1,0,2,3]'
    type: calcdist
  states: {}
- name: symbolrate
  id: variable
  parameters:
    value: bitrate/2
  states: {}
- name: transition_width
  id: variable
  parameters:
    comment: |-
      From passband
      to stopband
    value: stopband_start-passband_end
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: squelchAlpha
    gate: 'False'
    ramp: squelch_ramp
    threshold: squelch_level
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: 4GFSK to 4PAM
    gain: samp_rate/(decimation*2*math.pi*fsk_deviation)
  states: {}
- name: bitrate
  id: parameter
  parameters:
    label: Channel Bitrate (bps)
    type: intx
    value: '100000'
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '70'
    type: float
  states: {}
- name: blocks_add_const_vxx_1_0
  id: blocks_add_const_vxx
  parameters:
    comment: To [{-1},{1}] range
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: Compensates AGCs delay
    delay: int(compensation_delay_time*samp_rate_demod)
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(compensation_delay_time*samp_rate_demod)
    type: float
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '64'
    max_iter: '1000'
    scale: 1/64
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '64'
    max_iter: '1000'
    scale: 1/64
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.02'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '-2/fsk_deviation'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '-fsk_deviation'
    type: float
  states: {}
- name: blocks_multiply_const_xx_1_1
  id: blocks_multiply_const_xx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: 'k: offset calib.'
    k: power_offset_calib
    n: '10'
  states: {}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: For debug
    interp: '2'
    type: byte
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: ch_enable
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      Simbols to bits.
      Aplies K factor 
      interpolation
    k: '2'
  states: {}
- name: ch_enable
  id: parameter
  parameters:
    label: Channel Enable
    value: 'True'
  states: {}
- name: ch_number
  id: parameter
  parameters:
    label: Channel Number
    type: intx
    value: '1'
  states: {}
- name: crc_key
  id: parameter
  parameters:
    label: Channel CRC Key
    type: intx
    value: '0xFFFF'
  states: {}
- name: crc_polynomial
  id: parameter
  parameters:
    label: Channel CRC Polynomial
    type: intx
    value: '0x8005'
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: int(demod_dc_block_time*samp_rate_demod)
    long_form: 'False'
    type: ff
  states: {}
- name: debug_log
  id: parameter
  parameters:
    label: Channel Message Debug Log
    value: 'False'
  states: {}
- name: debug_log_verbosity
  id: parameter
  parameters:
    label: Debug on High Verbosity
    value: 'False'
  states: {}
- name: demod_dc_block_time
  id: parameter
  parameters:
    label: Demodulator DC Block Window Time (s)
    type: eng_float
    value: '6e-3'
  states: {}
- name: dewhitening_key
  id: parameter
  parameters:
    label: Channel Initial Dewhitening Key
    type: intx
    value: '0x1ff'
  states: {}
- name: digital_binary_slicer_fb_0_3
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Soft to hard simbols
    constellation: fourPamConstellation
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"1111011101011111110101110101011111110111010111111101011101010111"'
    comment: |-
      Using modified access code for
      2-GFSK sync code detection
    tagname: '"phyframe"'
    threshold: '0'
    type: float
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: None
    damping: loop_damping
    loop_bw: loop_bw
    max_dev: ted_max_deviation
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate_demod/symbolrate
    ted_gain: ted_gain
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, initial_PRBS_key=0x1FF, dewhite_CRC=True, debug_Log=False):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Verisure Dewhitener',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.key_init = initial_PRBS_key\n        self.enableDewhiteCRC = dewhite_CRC # adds the \"dewhited_crc\" key (and value) to the pdu metadata dictionary\n        self.log = debug_Log\n        if self.log: self.keys = [] # debug\n\n        self.message_port_register_in(pmt.intern('pdu_in')) # input message port definition\n        self.message_port_register_out(pmt.intern('pdu_out')) # output message port definition\n        self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu) # asociation of handler function to input\n\n    def handle_pdu(self, pdu): # called when a pdu has been published to 'pdu_in' message port\n        \n        # access to the pdu parts:\n        pduMetadataDictionary = pmt.car(pdu) # first field of pdu extracted\n        pduPayloadVector = pmt.to_python(pmt.cdr(pdu)) # second field of pdu extracted, which is the payload vector\n\n\n\n        dewhitedLengthField, lastPrbsKey = self.dewhite_lengtField(self, whitenedLengthField, initialPrbsKey):\n\n        dewhitedPayload, lastPrbsKey = self.dewhite_payload(pduPayloadVector) # list of dewhited bytes of the payload\n\n        if self.enableDewhiteCRC:\n            frameCrc = pmt.to_python(pmt.dict_ref(pduMetadataDictionary, pmt.intern(\"crc\"), pmt.PMT_NIL)) # access to crc key\n            dewhitedCRC = self.dewhite_crc(frameCrc, lastPrbsKey)\n            pduMetadataDictionary = pmt.dict_add(pduMetadataDictionary, pmt.intern(\"dewhited_crc\"),  pmt.from_long(dewhitedCRC))\n\n        if self.log: # Debug\n            binaryKeys = []\n            for key in self.keys:\n                binaryKeys.append(format(key, \"09b\"))\n            print ('')\n            print ('   2. Verisure Dewhitener debug message:')\n            print (' .----------------------------------------->')\n            print (' | Payload Length:', len(dewhitedPayload))\n            print (' | Dewhitened Payload Data in DEC:', dewhitedPayload)\n            print (' | Dewhitened CRC in DEC:', dewhitedCRC if self.enableDewhiteCRC else ' DISABLED')\n            print (' | PRBS generated keys:', binaryKeys)\n            print (' *----------------------------------------->')  \n            print ('')\n            self.keys.clear()\n\n        pdu = pmt.cons(pduMetadataDictionary, pmt.to_pmt(dewhitedPayload)) # builds a GNU Radio standarized PDU      \n        self.message_port_pub(pmt.intern('pdu_out'), pdu) # publishes PDU. args: port, message\n        \n\n    def calculateNextPRBSkey(self, currentKey): # calculates the next key of the pseudo random binary sequence with PRBS9 polynomial  \n        key = currentKey\n        for i in range (0,8):\n            msb = 0x1 & (key ^ (key >> 5)) # 1 bit, corresponds to the xor operation between bits 0 and 5 of the last key\n            nextKeyLsbByte = 0xFF & (key >> 1) # generates the 8 lsb's of the new key by shifting\n            key = (msb << 8) | nextKeyLsbByte # adds the precalculated msb to the 8 lsbs\n        return key\n\n    def dewhite_lengtField(self, whitenedLengthField, initialPrbsKey):\n        dewhitenedLength = 0\n        prbsKey = initialPrbsKey # initial pseudo random binary key\n        dewhitenedLength |= (0xFF & (whitenedLengthField ^ prbsKey)) # (dewhitened byte) == (byte xored with the key)\n        if self.log: self.keys.append(prbsKey) # debug\n        nextPrbsKey = self.calculateNextPRBSkey(prbsKey)\n        return dewhitenedLength, nextPrbsKey\n\n    def dewhite_payload(self, payloadVector, initialPrbsKey): # aplies dewithening algorithm to each byte of the payload\n        dewhitenedPayload = []\n        prbsKey = initialPrbsKey # initial pseudo random binary key\n        for byte in payloadVector:\n            dewhitenedPayload.append(0xFF & (byte ^ prbsKey)) # appends (dewhitened byte) == (byte xored with the key)\n            if self.log: self.keys.append(prbsKey) # debug\n            prbsKey = self.calculateNextPRBSkey(prbsKey)\n        return dewhitenedPayload, prbsKey # returns dewhitenedPayload list but also last generated prbsKey\n\n    def dewhite_crc(self, whitenedCRC, initialPrbsKey): # called after dewhite_payload, aplies dewithening algorithm to CRC\n        dewhitenedCRC = 0\n        prbsKey = initialPrbsKey\n        for i in range (1,-1,-1): # i = 1,0 (2 bytes of the CRC)\n            dewhitenedCRC |= (0xFF & (whitenedCRC ^ prbsKey)) << 8 * i # (dewhitened byte) == (byte xored with the key)\n            if self.log: self.keys.append(prbsKey) # debug\n            prbsKey = self.calculateNextPRBSkey(prbsKey)\n        return dewhitenedCRC\n\n\n\n\n"
    debug_Log: 'True'
    dewhite_CRC: 'True'
    initial_PRBS_key: '0x1E1'
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: selected_ch_freq - lo_osc_freq
    decim: decimation
    nthreads: '8'
    samp_delay: '1'
    samp_rate: samp_rate
    taps: ' firdes.low_pass_2(filterGain,samp_rate,cutoff_freq,transition_width,stop_band_attenuation_dB)'
  states: {}
- name: fsk_deviation
  id: parameter
  parameters:
    label: FSK Frequency Deviation
    type: eng_float
    value: 60e3
  states: {}
- name: lo_osc_freq
  id: parameter
  parameters:
    label: HW Local Oscillator Frequency (Hz)
    type: eng_float
    value: 869.3e6
  states: {}
- name: loop_bw
  id: parameter
  parameters:
    label: Loop BW
    type: eng_float
    value: '0.015'
  states: {}
- name: loop_damping
  id: parameter
  parameters:
    label: Loop Damping Factor
    type: eng_float
    value: '1.4'
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_rate/(decimation*bitrate)
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_rate/(decimation*bitrate)
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    note: symbols to bitstream ->
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: symbol sync ->
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: bitstream to PDU msg ->
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: message_out
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: xlating_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1_0_0
  id: pad_sink
  parameters:
    label: squelch_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1_0_0_0
  id: pad_sink
  parameters:
    label: demod_out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0_0_0_0
  id: pad_sink
  parameters:
    label: dc_block_out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0_0_0_0_0
  id: pad_sink
  parameters:
    label: lf_agc_out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0_0_0_0_0_0
  id: pad_sink
  parameters:
    label: ssync_out_out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0_0_0_0_0_0_0
  id: pad_sink
  parameters:
    label: ssync_err_out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0_0_0_0_0_0_0_0
  id: pad_sink
  parameters:
    label: ssync_tInst_out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0_0_0_0_0_0_0_0_0
  id: pad_sink
  parameters:
    label: ssync_tavg_out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0_0_0_0_0_0_0_0_0_0_0
  id: pad_sink
  parameters:
    label: bitstream_out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0_0_0_0_0_0_0_0_0_0_0_0
  id: pad_sink
  parameters:
    label: power_out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: pad_sink
  parameters:
    label: freq_err_out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0_0_0_0_0_0_0_0_0_0_1
  id: pad_sink
  parameters:
    label: correlator_out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0_0_0_0_0_0_0_0_0_0_1_0
  id: pad_sink
  parameters:
    label: ssync_bytes_out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0_0_0_0_0_0_0_0_0_0_1_0_0
  id: pad_sink
  parameters:
    label: ssync_bits_out
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: passband_end
  id: parameter
  parameters:
    label: Channel Filter Pass Band End Frequency (Hz)
    type: eng_float
    value: 85e3
  states: {}
- name: power_offset_calib
  id: parameter
  parameters:
    label: RSSI Calibration Offset (dB)
    type: eng_float
    value: '-15'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate (Hz)
    type: eng_float
    value: 13e6
  states: {}
- name: samp_rate_demod
  id: parameter
  parameters:
    label: Demodulator Sample Rate (Hz)
    type: eng_float
    value: 260e3
  states: {}
- name: selected_ch_freq
  id: parameter
  parameters:
    label: Channel Center Frequency (Hz)
    type: eng_float
    value: 868.15e6
  states: {}
- name: squelchAlpha
  id: parameter
  parameters:
    label: Squelch Alpha
    type: eng_float
    value: '300e-3'
  states: {}
- name: squelch_level
  id: parameter
  parameters:
    label: Squelch Threshold Level (dB)
    type: intx
    value: '-40'
  states: {}
- name: squelch_ramp
  id: parameter
  parameters:
    label: Squelch Ramp
    type: intx
    value: '8'
  states: {}
- name: stop_band_attenuation_dB
  id: parameter
  parameters:
    label: Channel Filter Stop Band Attenuation (Hz)
    type: intx
    value: '96'
  states: {}
- name: stopband_start
  id: parameter
  parameters:
    label: Channel Filter Stop Band Start Frequency (Hz)
    type: eng_float
    value: 95e3
  states: {}
- name: ted_gain
  id: parameter
  parameters:
    label: TED Gain
    type: eng_float
    value: '1'
  states: {}
- name: ted_max_deviation
  id: parameter
  parameters:
    label: TED Maximum deviation
    type: eng_float
    value: '1.5'
  states: {}
- name: verisure_crc_checker
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          # only default arguments here
          def __init__(self, crc_Polynomial=0x8005, crc_Init_Key=0xFFFF, debug_Log=False, high_Verbosity_Log=False):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Verisure CRC Checker',   # will show up in GRC
                  in_sig=None,  # there is no input stream
                  out_sig=None  # there is no output stream
              )

              # input message port definition
              self.message_port_register_in(pmt.intern('pdu_in'))
              # output message port definition
              self.message_port_register_out(pmt.intern('pdu_out'))
              # asociation of handler function to input
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu)

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.crcInit = crc_Init_Key
              self.crcPoly = crc_Polynomial
              self.log = debug_Log
              self.highVerbosity = high_Verbosity_Log

              if self.log:  # Debug
                  self.msgNumber = -1  # message indexer for debug
                  self.crcPassCount = 0  # message counter for debug
                  self.crcFailCount = 0  # message counter for debug

          def handle_pdu(self, pdu):  # called when a pdu has been published to 'pdu_in' message port

              # access to the pdu parts:
              pduMetadataDictionary = pmt.car(pdu)  # first field of pdu extracted
              # second field of pdu extracted, which is the payload vector
              pduPayloadVector = pmt.to_python(pmt.cdr(pdu))

              frameCrc = pmt.to_python(pmt.dict_ref(
                  pduMetadataDictionary, pmt.intern("crc"), pmt.PMT_NIL))  # access to crc key
              frameCrc16bit = self.bytes_to_16bit(frameCrc)

              # crc is calculated over the byte of the length + bytes of the payload
              lengthAndPayload = pduPayloadVector.copy()
              # length byte is inserted at position 0
              lengthAndPayload.insert(0, len(pduPayloadVector))
              # lengthAndPayload.append(len(pduPayloadVector))

              calculatedCrc = self.calculate_crc(lengthAndPayload)  # calculates crc
              # checks calculated and frame crc
              packetOk = 1 if frameCrc16bit == calculatedCrc else 0

              if self.log:  # Debug log
                  channel = int(pmt.to_python(pmt.dict_ref(pduMetadataDictionary, pmt.intern(
                      "channel_number"), pmt.PMT_NIL)))  # access to channel number
                  self.debug_log(channel, packetOk, pduPayloadVector,
                                 lengthAndPayload, frameCrc, frameCrc16bit, calculatedCrc)

              pduMetadataDictionary = pmt.dict_add(pduMetadataDictionary, pmt.intern(
                  "calculated_crc"),  pmt.from_long(calculatedCrc))
              pduMetadataDictionary = pmt.dict_add(
                  pduMetadataDictionary, pmt.intern("crc_check"),  pmt.from_long(packetOk))

              # builds a GNU Radio standarized PDU
              pdu = pmt.cons(pduMetadataDictionary, pmt.to_pmt(pduPayloadVector))
              # publishes PDU. args: port, message
              self.message_port_pub(pmt.intern('pdu_out'), pdu)

          # Update CRC register with new byte (ported code from c)

          def update_crc(self, data, crc_reg):
              bitMask8 = 0xFF  # a bit mask to make Python variables behave like u8_t when shifting
              bitMask16 = 0xFFFF  # a bit mask to make Python variables behave like u16_t when shifting
              data &= bitMask8
              for i in range(0, 8):
                  if (bitMask16 & ((crc_reg & 0x8000) >> 8)) ^ (data & 0x80):
                      crc_reg = (bitMask16 & (crc_reg << 1)) ^ self.crcPoly
                  else:
                      crc_reg = bitMask16 & (crc_reg << 1)
                  data = bitMask8 & (data << 1)
              return crc_reg

          # Calculate CRC value on byte array using above function (ported code from c)
          def calculate_crc(self, data):
              crc = self.crcInit
              for byte in data:
                  crc = self.update_crc(byte, crc)
              return crc

          # Converts a list of two bytes into a big-endian 16 bit value
          def bytes_to_16bit(self, list):
              try:
                  return ((list[0] & 0xFF) << 8) | (0xFF & list[1])
              except:  # if by any reason one of the positions of the list is not defined
                  return 0

          # Converts a list of two bytes into a big-endian 16 bit value (for DEBUG)

          def from16bit_to_bytes(self, value):
              out = [None]*2  # initializing a 2 element list
              value = 0xFFFF & value
              out[0] = (0xFF00 & value) >> 8
              out[1] = (0x00FF & value)
              return out

          # Log
          def debug_log(self, channel, packetOk, pduPayloadVector, lengthAndPayload, frameCrc, frameCrc16bit, calculatedCrc):

              self.msgNumber += 1
              if packetOk:
                  self.crcPassCount += 1
              else:
                  self.crcFailCount += 1
              passPercentage = (self.crcPassCount/(self.msgNumber + 1))*100
              failPercentage = (self.crcFailCount/(self.msgNumber + 1))*100

              if self.highVerbosity:  # high verbosity mode
                  calculatedCRCinBytes = self.from16bit_to_bytes(calculatedCrc)
                  print('')
                  print('  Verisure CRC Checker debug message:')
                  print(' .----------------------------------------->')
                  print(' | Channel:', channel)
                  print(' | ----------------------------------------')
                  print(' | Payload Length:', len(pduPayloadVector))
                  print(' | Length + Dewhitened Payload Data in DEC:', lengthAndPayload)
                  print(' | Length + Dewhitened Payload Data in HEX:',
                        [format(byte, "02X") for byte in lengthAndPayload])
                  print(' | ----------------------------------------')
                  print(' | Frame CRC in DEC (2-byte representation):', frameCrc)
                  print(' | Calculated CRC in DEC (2-byte representation):',
                        calculatedCRCinBytes)
                  print(' | ----------------------------------------')
                  print(' | Frame CRC in BIN      (2-byte representation):',
                        [format(byte, "08b") for byte in frameCrc])
                  print(' | Calculated CRC in BIN (2-byte representation):',
                        [format(byte, "08b") for byte in calculatedCRCinBytes])
                  print(' | ----------------------------------------')
                  print(' | Frame CRC in DEC (16 bit representation):', frameCrc16bit)
                  print(' | Calculated CRC in DEC (16 bit representation):', calculatedCrc)
                  print(' | ----------------------------------------')
                  print(' | Msg. number (first is number 0):', self.msgNumber)
                  print(' | CRC Check:', 'PASSED' if packetOk else 'FAILED')
                  print(' | ----------------------------------------')
                  print(' | Pass rate:', passPercentage, '%')
                  print(' | Failure rate:', failPercentage, '%')
                  print(' *----------------------------------------->')
                  print('')
              else:  # low verbosity mode
                  """
                  print ('')
                  print ('   2. Verisure CRC Checker debug message:')
                  print (' .----------------------------------------->')
                  print (' | Msg. number (from #0):', self.msgNumber )     
                  print (' | CRC Check:', 'PASSED' if packetOk else 'FAILED!')
                  print (' | Pass rate:', passPercentage, '%' )  
                  print (' | Failure rate:', failPercentage, '%' )  
                  print (' | (Packets with failed CRC / All packets received):', self.crcFailCount, '/', self.msgNumber + 1 )
                  print (' *----------------------------------------->')  
                  print ('')
                  """
                  print('Channel:', channel, 'Msg. number (first is number 0):', self.msgNumber, 'CRC Check:', 'PASSED' if packetOk else 'FAILED!',
                        '(Packets with failed CRC / All packets received):', self.crcFailCount, '/', self.msgNumber + 1)
    crc_Init_Key: crc_key
    crc_Polynomial: crc_polynomial
    debug_Log: debug_log
    high_Verbosity_Log: debug_log_verbosity
  states: {}
- name: verisure_float_to_msg_resamp_ratio_converter
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, decimation=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name=' Verisure Float to Msg Resamp Ratio Converter',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None
              )

              self.message_port_register_out(pmt.intern('msg_out')) # output message port definition

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.decimation = decimation

          def work(self, input_items, output_items):
              
              paramDictionary = pmt.make_dict()
              paramDictionary = pmt.dict_add(paramDictionary, pmt.intern("resamp_ratio"),  pmt.from_double(float(input_items[0][0])/self.decimation)) 
              self.message_port_pub(pmt.intern('msg_out'), paramDictionary) # publishes PDU to subscriber blocks. args: port, message

              return len(input_items[0])
    decimation: '2'
  states: {}
- name: verisure_tag_counter
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, enable_Log=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Verisure Tag Counter',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None              # there is no output stream
              )
              
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.enableLog = enable_Log
              
              self.tagCounter = 0

          def work(self, input_items, output_items):
              
              
              tags = self.get_tags_in_window(0, 0, len(input_items[0])) # gets all tags in current buffer. Params: input, rel. start, rel. end
              for tag in tags:
                  self.tagCounter += 1
               
              if self.enableLog and (len(tags) > 0):
                  print ('')
                  print ('   0. Verisure Tag Counter:')
                  print (' .----------------------------------------->')
                  print (' | Tag Count:', self.tagCounter)
                  print (' *----------------------------------------->')
                  print ('')
              return len(input_items[0])
    enable_Log: 'True'
  states: {state: disabled}
- name: verisure_tagged_bitstream_to_pdu
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      from datetime import datetime # for timestamping
      # import queue

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          class Frame(): # auxiliar inner class for storing all the data requiered to parse a frame
              def __init__(self, tagAbsolutePosition, timestamp, power, freqError, initial_PRBS_key): # Constructor
                  
                  self.tagAbsolutePosition = tagAbsolutePosition # absolute offset in the stream of the tag of the frame
                  self.timestamp = timestamp # timestamp of tag of the frame
                  self.power = power # measure of the power of the signal at the time of the tag
                  self.freqError = freqError # measure of the power of the signal at the time of the tag
                  
                  self.nextBitIndexToParse = 0 # index of the next bite of the frame to process
                  self.byteBitMask = 0x80 # bit mask for parsing bits in the bytes of the frame
                  self.currentByteBeingParsed = 0 # stores current byte of the payload being parsed
                  
                  self.payloadLength = 0 # length of the payload expressed in bytes (not including CRC)
                  self.payload = [] # list of bytes of the payload, big endian
                  self.crc = [] # list of bytes of the crc, big endian
                  
                  self.currentDewhiteningKey = initial_PRBS_key # initial key for dewhitening
                  
                  
          # Constructor
          def __init__(self, channelNumerator=1, initial_Dewhitening_key=0x1FF, debug_Log_frame=False, debug_Log_control_traces=False):  # default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__( # father constructor call
                  self,
                  name='Verisure Tagged Bistream to PDU',   # will show up in GRC
                  in_sig=[np.int8,np.float32,np.float32],
                  out_sig=None # there is no output stream
              )

              self.message_port_register_out(pmt.intern('pdu_out')) # output message port definition

              # block constants definition
              self.BITS_IN_A_BYTE = 8
              self.CRC_LENGTH = 16 # in bits

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.channelNumber = channelNumerator # number of channel for displaying on RfAnalyzer
              self.dewhitening_key_init = initial_Dewhitening_key
              self.logBlock = debug_Log_frame # debug log switch for frame info
              self.logCtrl = debug_Log_control_traces # debug log switch for internal block control depuration traces

              # block atributes initialization (retain data between calls of the work function) 
              self.currentFrameInProcess = None # stores the Frame being parsed between two calls of the work function
              
              # self.msb_0 = 0x80 # Used in Carlos dewhitening algorithm
              # self.msb_1 = 0x80

          def work(self, input_items, output_items): # called for every buffer of samples received
              
              # finish processing the currentFrameInProcess from the previous call to the work function
              if self.currentFrameInProcess != None:
                  processedFrame, returnValue = self.continueFrameProcessing(input_items, self.currentFrameInProcess)
                  if returnValue == 1:      # if the parsing of the currentFrameInProcess from the previous window is finished then clean currentFrameInProcess
                      self.currentFrameInProcess = None  
                  elif returnValue == 0:    # else, currentFrameInProcess will be updated to be processed on next window
                      self.currentFrameInProcess = processedFrame

              tags = self.get_tags_in_window(0, 0, len(input_items[0])) # gets all tags in current buffer. Params: input, rel. start, rel. end
              
              for tag in tags: # itereate over all tags of the window in chronological order. 
                               # on case of error of a length field, a new tag always has priority over the last
                               # that is why self.currentFrameInProcess can be overwrited multiple times

                  if self.logCtrl: print ('New tag has been detected')

                  tagAbsPosition = tag.offset # absolute position of the tag in the stream

                  if self.logBlock: # Debug
                      key = pmt.to_python(tag.key) # convert from PMT to python string
                      value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                      index = tagAbsPosition - self.nitems_read(0) # index == relative position of the tag in the current buffer
                      print ('')
                      print ('   1. Verisure Tagged Bistream to PDU debug message:')
                      print (' .----------------------------------------->')
                      print (' | Channel Number:', self.channelNumber)
                      print (' | Input tag key:', key)
                      print (' | Input tag value:', value)
                      print (' | Input tag value type:', type(value))
                      print (' | Input tag abs. position (offset):', tagAbsPosition)
                      print (' | Input tag rel. position (offset):', index)

                  processedFrame, returnValue = self.startFrameProcessing(tagAbsPosition, input_items) 
                  if returnValue == 1:      # if the parsing of the frame is finished then clean currentFrameInProcess
                      self.currentFrameInProcess = None  
                  elif returnValue == 0:    # else, last frame will be overwrited
                      self.currentFrameInProcess = processedFrame
                  
              return len(input_items[0])
          
          
          def startFrameProcessing(self, tagAbsoluteOffset, input_items): # initiates the process of a frame (called when a tag is found in the stream)

              if self.logCtrl: print ('Start Frame Processing')

              # initializing values for a new frame
              timestamp = datetime.timestamp(datetime.now()) # getting the timestamp from datetime
              power = input_items[1][tagAbsoluteOffset - self.nitems_read(0)] # reads power input @ tag time
              freqError = input_items[2][tagAbsoluteOffset - self.nitems_read(0)] # reads freq. error input @ tag time
              
              currentFrame = self.Frame(tagAbsoluteOffset, timestamp, power, freqError, self.dewhitening_key_init) # creates a frame object
              return self.continueFrameProcessing(input_items, currentFrame)
              
          
          def continueFrameProcessing(self, input_items, currentFrame): # parses a frame until the actual buffer is empty or the last bite of the crc is parsed

              if self.logCtrl: print ('Continue Frame Processing')
              
              # position of tag in current window (may be < 0 if the tag was captured in a previous call to the work function)
              frameTagRelativePosition = currentFrame.tagAbsolutePosition - self.nitems_read(0) 
              
              while frameTagRelativePosition + currentFrame.nextBitIndexToParse < len(input_items[0]): # iterate over current window samples
                  
                  # 1. [HEADER LENGTH] field parsing
                  if currentFrame.nextBitIndexToParse < self.BITS_IN_A_BYTE: 

                      if input_items[0][frameTagRelativePosition + currentFrame.nextBitIndexToParse] != 0: 
                          currentFrame.payloadLength |= currentFrame.byteBitMask # raises a bit in the length byte
                      currentFrame.byteBitMask >>= 1  # updates bitmask

                      if currentFrame.nextBitIndexToParse == self.BITS_IN_A_BYTE - 1: # last bite of the whitened length field is saved
                          currentFrame.payloadLength = (0xFF & (currentFrame.payloadLength ^ currentFrame.currentDewhiteningKey)) # dewhitening
                          currentFrame.byteBitMask = 0x80 # resets the bit mask for reusing it in payload parsing

                  # 2. [PAYLOAD] parsing   
                  elif currentFrame.nextBitIndexToParse < self.BITS_IN_A_BYTE + self.BITS_IN_A_BYTE * currentFrame.payloadLength: 

                      if input_items[0][frameTagRelativePosition + currentFrame.nextBitIndexToParse] != 0:
                          currentFrame.currentByteBeingParsed |= currentFrame.byteBitMask # raises a bit in the current byte
                      currentFrame.byteBitMask >>= 1 # updates bitmask

                      if (currentFrame.nextBitIndexToParse - self.BITS_IN_A_BYTE) % self.BITS_IN_A_BYTE == self.BITS_IN_A_BYTE - 1:  # last bit of the byte
                          currentFrame.currentDewhiteningKey = self.calculateNextPRBSkey(currentFrame.currentDewhiteningKey) # updates dewhitening key
                          dewhitenedByte = 0xFF & (currentFrame.currentByteBeingParsed ^ currentFrame.currentDewhiteningKey) # aplies dewhitening with the key
                          currentFrame.payload.append(dewhitenedByte) # stores current byte
                          currentFrame.byteBitMask = 0x80 # resets the bit mask
                          currentFrame.currentByteBeingParsed = 0 # resets the current byte (starts over from 0)

                  # 3. [CRC] parsing
                  elif currentFrame.nextBitIndexToParse < self.BITS_IN_A_BYTE + self.BITS_IN_A_BYTE * currentFrame.payloadLength + self.CRC_LENGTH: 
                     
                      if input_items[0][frameTagRelativePosition + currentFrame.nextBitIndexToParse] != 0:
                          currentFrame.currentByteBeingParsed |= currentFrame.byteBitMask # raises a bit in the current byte
                      currentFrame.byteBitMask >>= 1 # updates bitmask

                      if (currentFrame.nextBitIndexToParse - self.BITS_IN_A_BYTE) % self.BITS_IN_A_BYTE == self.BITS_IN_A_BYTE - 1:  # last bit of the byte
                          currentFrame.currentDewhiteningKey = self.calculateNextPRBSkey(currentFrame.currentDewhiteningKey) # updates dewhitening key
                          dewhitenedByte = 0xFF & (currentFrame.currentByteBeingParsed ^ currentFrame.currentDewhiteningKey) # aplies dewhitening with the key
                          currentFrame.crc.append(dewhitenedByte) # stores current byte
                          currentFrame.byteBitMask = 0x80 # resets the bit mask
                          currentFrame.currentByteBeingParsed = 0 # resets the current byte (starts over from 0)     
                     
                  # 4. END
                  else: # end of frame (the last bit of the crc has been parsed)
                      self.endFrameProcessing(currentFrame)
                      return currentFrame, 1 # == the current frame has been parsed successfully (end of the frame)
                      
                  currentFrame.nextBitIndexToParse += 1 # process next bit
                  
              return currentFrame, 0 # == the current frame will have to continue being parsed on next call to work function


          def endFrameProcessing(self, currentFrame): # finish processing of frame and packs & sends the PDU through message port

              if self.logCtrl: print ('End Frame Processing')

              if self.logBlock: # Debug
                  binaryPayload = []
                  for byte in currentFrame.payload:
                      binaryPayload.append(format(byte, "08b"))
                  print (' | Payload length:', currentFrame.payloadLength)
                  print (' | Captured payload in DEC:', currentFrame.payload)
                  print (' | Captured payload in BIN:', binaryPayload)
                  print (' | Captured CRC in DEC:', currentFrame.crc)
                  print (' | Timestamp:', currentFrame.timestamp)
                  print (' | Date and Time:', datetime.fromtimestamp(currentFrame.timestamp))
                  print (' | Power:', currentFrame.power)
                  print (' | Freq. error:', currentFrame.freqError)
                  print (' *----------------------------------------->')
                  print ('')
                  
                  
              metadataDictionary = pmt.make_dict()
              metadataDictionary = pmt.dict_add(metadataDictionary, pmt.intern("channel_number"), pmt.from_double(self.channelNumber))
              metadataDictionary = pmt.dict_add(metadataDictionary, pmt.intern("payload_length"), pmt.from_long(currentFrame.payloadLength)) # args: dictionary, key, value
              metadataDictionary = pmt.dict_add(metadataDictionary, pmt.intern("crc"),  pmt.to_pmt(currentFrame.crc)) 
              metadataDictionary = pmt.dict_add(metadataDictionary, pmt.intern("timestamp"),  pmt.from_double(currentFrame.timestamp)) 
              metadataDictionary = pmt.dict_add(metadataDictionary, pmt.intern("power"),  pmt.from_double(float(currentFrame.power))) 
              metadataDictionary = pmt.dict_add(metadataDictionary, pmt.intern("freq_error"),  pmt.from_double(float(currentFrame.freqError))) 
              pdu = pmt.cons(metadataDictionary, pmt.to_pmt(currentFrame.payload)) # builds a GNU Radio standarized PDU
              self.message_port_pub(pmt.intern('pdu_out'), pdu) # publishes PDU to subscriber blocks. args: port, message
              
        
          # DEWHITENING-----------
             
          def calculateNextPRBSkey(self, currentKey): # calculates the next key of the pseudo random binary sequence with PRBS9 polynomial (DEWHITENING)
              key = currentKey
              for i in range (0,8):
                  msb = 0x1 & (key ^ (key >> 5)) # 1 bit, corresponds to the xor operation between bits 0 and 5 of the last key
                  nextKeyLsbByte = 0xFF & (key >> 1) # generates the 8 lsb's of the new key by shifting
                  key = (msb << 8) | nextKeyLsbByte # adds the precalculated msb to the 8 lsbs
              return key
          
          """
          # Carlos Algorithm (produces same result)
          def calculateNextPRBSkey(self, currentKey): # calculates the next key of the pseudo random binary sequence with PRBS9 polynomial (DEWHITENING)
              key = currentKey
              for i in range (0,8):
                  self.msb_1 = 0xFF & (((key & 0x01) ^ ((key & 0x20)>>5))<<7)
                  key = (key>>1) | (0xFF & self.msb_0)
                  self.msb_0 = (0xFF & self.msb_1)
              return key
          """    
    channelNumerator: ch_number
    debug_Log_control_traces: 'False'
    debug_Log_frame: 'False'
    initial_Dewhitening_key: dewhitening_key
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: fourPAM
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    comment: for RSSI sampling
    stream_id: power
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: resamp_ratio
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    comment: '4-PAM Range: [-1,1]'
    stream_id: soft_symbols
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: tagged_bitstream
  states: {}
- name: virtual_sink_0_2
  id: virtual_sink
  parameters:
    stream_id: freq_error
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: fourPAM
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: power
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: freq_error
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: resamp_ratio
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: resamp_ratio
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    comment: '4-PAM Range: [-1,1]'
    stream_id: soft_symbols
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tagged_bitstream
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_tag_gate_0, '0']
- [analog_pwr_squelch_xx_0, '0', pad_sink_1_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', dc_blocker_xx_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', mmse_resampler_xx_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', pad_sink_1_0_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_add_const_vxx_1_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_multiply_const_xx_1_1, '0']
- [blocks_char_to_float_0_0, '0', pad_sink_1_0_0_0_0_0_0_0_0_0_0_1_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', pad_sink_1_0_0_0_0_0_0_0_0_0_0_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_delay_0, '0', virtual_sink_0_0, '0']
- [blocks_delay_0_0, '0', virtual_sink_0_2, '0']
- [blocks_float_to_complex_1, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_multiply_const_xx_0_0_0_0, '0']
- [blocks_multiply_const_xx_0_0, '0', pad_sink_1_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_multiply_const_xx_0_0_0, '0', pad_sink_1_0_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_multiply_const_xx_0_0_0_0, '0', blocks_delay_0_0, '0']
- [blocks_multiply_const_xx_1_1, '0', blocks_add_const_vxx_1_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_delay_0, '0']
- [blocks_null_source_1, '0', blocks_float_to_complex_1, '1']
- [blocks_repeat_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_selector_0_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_tag_gate_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_uchar_to_float_0, '0', pad_sink_1_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_uchar_to_float_0_1_0, '0', pad_sink_1_0_0_0_0_0_0_0_0_0_0_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [dc_blocker_xx_0_0, '0', pad_sink_1_0_0_0_0, '0']
- [dc_blocker_xx_0_0, '0', virtual_sink_0, '0']
- [digital_binary_slicer_fb_0_3, '0', blocks_uchar_to_float_0_1_0, '0']
- [digital_binary_slicer_fb_0_3, '0', virtual_sink_0_1_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repeat_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', digital_binary_slicer_fb_0_3, '0']
- [digital_correlate_access_code_tag_xx_0, '0', verisure_tag_counter, '0']
- [digital_symbol_sync_xx_0, '0', pad_sink_1_0_0_0_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0_0_1, '0']
- [digital_symbol_sync_xx_0, '1', pad_sink_1_0_0_0_0_0_0_0, '0']
- [digital_symbol_sync_xx_0, '2', pad_sink_1_0_0_0_0_0_0_0_0, '0']
- [digital_symbol_sync_xx_0, '3', pad_sink_1_0_0_0_0_0_0_0_0_0, '0']
- [digital_symbol_sync_xx_0, '3', verisure_float_to_msg_resamp_ratio_converter, '0']
- [freq_xlating_fft_filter_ccc_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', mmse_resampler_xx_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', pad_sink_1, '0']
- [mmse_resampler_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [mmse_resampler_xx_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [pad_source_0, '0', blocks_selector_0_0, '0']
- [verisure_crc_checker, pdu_out, pad_sink_0, in]
- [verisure_float_to_msg_resamp_ratio_converter, msg_out, virtual_sink_0_0_0, '0']
- [verisure_tagged_bitstream_to_pdu, pdu_out, verisure_crc_checker, pdu_in]
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0, '0', pad_sink_1_0_0_0_0_0, '0']
- [virtual_source_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [virtual_source_0_0, '0', verisure_tagged_bitstream_to_pdu, '1']
- [virtual_source_0_0_0, '0', blocks_multiply_const_xx_0_0_0, '0']
- [virtual_source_0_0_0, '0', verisure_tagged_bitstream_to_pdu, '2']
- [virtual_source_0_1, '0', mmse_resampler_xx_0, msg_in]
- [virtual_source_0_1_0, '0', mmse_resampler_xx_0_0, msg_in]
- [virtual_source_0_2, '0', blocks_float_to_complex_1, '0']
- [virtual_source_1, '0', blocks_uchar_to_float_0, '0']
- [virtual_source_1, '0', verisure_tagged_bitstream_to_pdu, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
