options:
  parameters:
    author: Francisco Nicolás Pérez Fernández
    copyright: Verisure 2021-2022
    description: A multichannel TCP server sniffer for the Verisure ISM Channels
    generate_options: no_gui
    id: multichannelSniffer
    output_language: python
    realtime_scheduling: '1'
    title: Multichannel Sniffer
  states: {}

blocks:
- name: all_channel_log
  id: variable_config
  parameters:
    config_file: multichannelSnifferConfig.conf
    option: all_channel_log
    section: DEBUG_LOG
    type: bool
    value: 'False'
    writeback: None
  states: {}
- name: antialiass_filter_bw
  id: variable_config
  parameters:
    config_file: configFile
    option: antialiasing_filter_bandwidth
    section: HW_SOURCE_CONFIG
    type: real
    value: 3.5e6
    writeback: None
  states: {}
- name: bitrate_s
  id: variable_config
  parameters:
    config_file: configFile
    option: baseband_bitrate
    section: 2GFSK_CHANNELS
    type: int
    value: '38400'
    writeback: None
  states: {}
- name: ch100Bitrate_h
  id: variable_config
  parameters:
    config_file: configFile
    option: baseband_bitrate_ch100
    section: 4GFSK_CHANNELS
    type: int
    value: '100000'
    writeback: None
  states: {}
- name: ch100enable
  id: variable_config
  parameters:
    config_file: configFile
    option: ch_100_enable
    section: 4GFSK_CHANNELS
    type: bool
    value: 'True'
    writeback: None
  states: {}
- name: ch100freq_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch100_center_freq
    section: 4GFSK_CHANNELS
    type: real
    value: 869.525e6
    writeback: None
  states: {}
- name: ch1_number_s
  id: variable_config
  parameters:
    config_file: configFile
    option: ch1_override_ch_number
    section: 2GFSK_CHANNELS
    type: int
    value: '1'
    writeback: None
  states: {}
- name: ch1enable
  id: variable_config
  parameters:
    config_file: configFile
    option: ch_1_enable
    section: 2GFSK_CHANNELS
    type: bool
    value: 'True'
    writeback: None
  states: {}
- name: ch1freq_s
  id: variable_config
  parameters:
    config_file: configFile
    option: ch_1_center_freq
    section: 2GFSK_CHANNELS
    type: real
    value: 868.150e6
    writeback: None
  states: {}
- name: ch200Bitrate_h
  id: variable_config
  parameters:
    config_file: configFile
    option: baseband_bitrate_ch200
    section: 4GFSK_CHANNELS
    type: int
    value: '200000'
    writeback: None
  states: {}
- name: ch200enable
  id: variable_config
  parameters:
    config_file: configFile
    option: ch_200_enable
    section: 4GFSK_CHANNELS
    type: bool
    value: 'True'
    writeback: None
  states: {}
- name: ch200freq_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch200_center_freq
    section: 4GFSK_CHANNELS
    type: real
    value: 869.525e6
    writeback: None
  states: {}
- name: ch2_number_s
  id: variable_config
  parameters:
    config_file: configFile
    option: ch2_override_ch_number
    section: 2GFSK_CHANNELS
    type: int
    value: '2'
    writeback: None
  states: {}
- name: ch2enable
  id: variable_config
  parameters:
    config_file: configFile
    option: ch_2_enable
    section: 2GFSK_CHANNELS
    type: bool
    value: 'True'
    writeback: None
  states: {}
- name: ch2freq_s
  id: variable_config
  parameters:
    config_file: configFile
    option: ch_2_center_freq
    section: 2GFSK_CHANNELS
    type: real
    value: 868.300e6
    writeback: None
  states: {}
- name: ch3_number_s
  id: variable_config
  parameters:
    config_file: configFile
    option: ch3_override_ch_number
    section: 2GFSK_CHANNELS
    type: int
    value: '3'
    writeback: None
  states: {}
- name: ch3enable
  id: variable_config
  parameters:
    config_file: configFile
    option: ch_3_enable
    section: 2GFSK_CHANNELS
    type: bool
    value: 'True'
    writeback: None
  states: {}
- name: ch3freq_s
  id: variable_config
  parameters:
    config_file: configFile
    option: ch_3_center_freq
    section: 2GFSK_CHANNELS
    type: real
    value: 868.450e6
    writeback: None
  states: {}
- name: ch4_number_s
  id: variable_config
  parameters:
    config_file: configFile
    option: ch4_override_ch_number
    section: 2GFSK_CHANNELS
    type: int
    value: '4'
    writeback: None
  states: {}
- name: ch4enable
  id: variable_config
  parameters:
    config_file: configFile
    option: ch_4_enable
    section: 2GFSK_CHANNELS
    type: bool
    value: 'True'
    writeback: None
  states: {}
- name: ch4freq_s
  id: variable_config
  parameters:
    config_file: configFile
    option: ch_4_center_freq
    section: 2GFSK_CHANNELS
    type: real
    value: 868.900e6
    writeback: None
  states: {}
- name: ch5_number_s
  id: variable_config
  parameters:
    config_file: configFile
    option: ch5_override_ch_number
    section: 2GFSK_CHANNELS
    type: int
    value: '5'
    writeback: None
  states: {}
- name: ch5enable
  id: variable_config
  parameters:
    config_file: configFile
    option: ch_5_enable
    section: 2GFSK_CHANNELS
    type: bool
    value: 'True'
    writeback: None
  states: {}
- name: ch5freq_s
  id: variable_config
  parameters:
    config_file: configFile
    option: ch_5_center_freq
    section: 2GFSK_CHANNELS
    type: real
    value: 869.050e6
    writeback: None
  states: {}
- name: ch600Bitrate_h
  id: variable_config
  parameters:
    config_file: configFile
    option: baseband_bitrate_ch600
    section: 4GFSK_CHANNELS
    type: int
    value: '600000'
    writeback: None
  states: {}
- name: ch600enable
  id: variable_config
  parameters:
    config_file: configFile
    option: ch_600_enable
    section: 4GFSK_CHANNELS
    type: bool
    value: 'True'
    writeback: None
  states: {}
- name: ch600freq_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch600_center_freq
    section: 4GFSK_CHANNELS
    type: real
    value: 868.975e6
    writeback: None
  states: {}
- name: ch800Bitrate_h
  id: variable_config
  parameters:
    config_file: configFile
    option: baseband_bitrate_ch800
    section: 4GFSK_CHANNELS
    type: int
    value: '800000'
    writeback: None
  states: {}
- name: ch800enable
  id: variable_config
  parameters:
    config_file: configFile
    option: ch_800_enable
    section: 4GFSK_CHANNELS
    type: bool
    value: 'True'
    writeback: None
  states: {}
- name: ch800freq_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch800_center_freq
    section: 4GFSK_CHANNELS
    type: real
    value: 868.3e6
    writeback: None
  states: {}
- name: configFile
  id: variable_config
  parameters:
    comment: |-
      Select which channel 
      configuration file is 
      loaded from the main
      configuration file
    config_file: multichannelSnifferConfig.conf
    option: channel_configuration_file
    section: CONFIG_FILES
    type: string
    value: multichannelSnifferConfigEurope.conf
    writeback: None
  states: {}
- name: crc_key
  id: variable_config
  parameters:
    config_file: multichannelSnifferConfig.conf
    option: crc_key
    section: FRAME_DECODING
    type: int
    value: '0xFFFF'
    writeback: None
  states: {}
- name: crc_polynomial
  id: variable_config
  parameters:
    config_file: multichannelSnifferConfig.conf
    option: crc_polynomial
    section: FRAME_DECODING
    type: int
    value: '0x8005'
    writeback: None
  states: {}
- name: debug_log_server
  id: variable_config
  parameters:
    config_file: multichannelSnifferConfig.conf
    option: server_debug_log
    section: DEBUG_LOG
    type: bool
    value: 'True'
    writeback: None
  states: {}
- name: demod_dc_block_time_100_h
  id: variable_config
  parameters:
    config_file: configFile
    option: dc_blocking_time_ch100
    section: 4GFSK_CHANNELS
    type: real
    value: '6e-3'
    writeback: None
  states: {}
- name: demod_dc_block_time_200_h
  id: variable_config
  parameters:
    config_file: configFile
    option: dc_blocking_time_ch200
    section: 4GFSK_CHANNELS
    type: real
    value: '6e-3'
    writeback: None
  states: {}
- name: demod_dc_block_time_600_h
  id: variable_config
  parameters:
    config_file: configFile
    option: dc_blocking_time_ch600
    section: 4GFSK_CHANNELS
    type: real
    value: '6e-3'
    writeback: None
  states: {}
- name: demod_dc_block_time_800_h
  id: variable_config
  parameters:
    config_file: configFile
    option: dc_blocking_time_ch800
    section: 4GFSK_CHANNELS
    type: real
    value: '6e-3'
    writeback: None
  states: {}
- name: demod_dc_block_time_s
  id: variable_config
  parameters:
    config_file: configFile
    option: dc_blocking_time
    section: 2GFSK_CHANNELS
    type: real
    value: '6e-3'
    writeback: None
  states: {}
- name: dewhitening_key
  id: variable_config
  parameters:
    config_file: multichannelSnifferConfig.conf
    option: dewhitening_key
    section: FRAME_DECODING
    type: int
    value: '0x1ff'
    writeback: None
  states: {}
- name: fsk_deviation_100_h
  id: variable_config
  parameters:
    config_file: configFile
    option: frequency_deviation_ch100
    section: 4GFSK_CHANNELS
    type: real
    value: '60000.0'
    writeback: None
  states: {}
- name: fsk_deviation_200_h
  id: variable_config
  parameters:
    config_file: configFile
    option: frequency_deviation_ch200
    section: 4GFSK_CHANNELS
    type: real
    value: '75000.0'
    writeback: None
  states: {}
- name: fsk_deviation_600_h
  id: variable_config
  parameters:
    config_file: configFile
    option: frequency_deviation_ch600
    section: 4GFSK_CHANNELS
    type: real
    value: '135000.0'
    writeback: None
  states: {}
- name: fsk_deviation_800_h
  id: variable_config
  parameters:
    config_file: configFile
    option: frequency_deviation_ch800
    section: 4GFSK_CHANNELS
    type: real
    value: '165000.0'
    writeback: None
  states: {}
- name: fsk_deviation_s
  id: variable_config
  parameters:
    config_file: configFile
    option: frequency_deviation
    section: 2GFSK_CHANNELS
    type: real
    value: 19.775e3
    writeback: None
  states: {}
- name: high_verbosity_all_channel_log
  id: variable_config
  parameters:
    config_file: multichannelSnifferConfig.conf
    option: high_verbosity_all_channel_log
    section: DEBUG_LOG
    type: bool
    value: 'False'
    writeback: None
  states: {}
- name: high_verbosity_debug
  id: variable_config
  parameters:
    config_file: multichannelSnifferConfig.conf
    option: high_verbosity_individual_channel_log
    section: DEBUG_LOG
    type: bool
    value: 'False'
    writeback: None
  states: {}
- name: if_gain
  id: variable_config
  parameters:
    config_file: configFile
    option: intermediate_frequency_amplifier_gain
    section: HW_SOURCE_CONFIG
    type: int
    value: '16'
    writeback: None
  states: {}
- name: lna_on
  id: variable_config
  parameters:
    config_file: configFile
    option: enable_rf_low_noise_amplifier
    section: HW_SOURCE_CONFIG
    type: bool
    value: 'True'
    writeback: None
  states: {}
- name: lo_osc_freq
  id: variable_config
  parameters:
    config_file: configFile
    option: local_oscillator_frequency
    section: HW_SOURCE_CONFIG
    type: real
    value: 869.3e6
    writeback: None
  states: {}
- name: lo_osc_freq_error_correction
  id: variable_config
  parameters:
    config_file: configFile
    option: local_oscillator_frequency_correction
    section: HW_SOURCE_CONFIG
    type: real
    value: '0.0'
    writeback: None
  states: {}
- name: loop_bw_100_h
  id: variable_config
  parameters:
    config_file: configFile
    option: symbol_sync_loop_bandwidth_ch100
    section: 4GFSK_CHANNELS
    type: real
    value: '0.015'
    writeback: None
  states: {}
- name: loop_bw_200_h
  id: variable_config
  parameters:
    config_file: configFile
    option: symbol_sync_loop_bandwidth_ch200
    section: 4GFSK_CHANNELS
    type: real
    value: '0.015'
    writeback: None
  states: {}
- name: loop_bw_600_h
  id: variable_config
  parameters:
    config_file: configFile
    option: symbol_sync_loop_bandwidth_ch600
    section: 4GFSK_CHANNELS
    type: real
    value: '0.015'
    writeback: None
  states: {}
- name: loop_bw_800_h
  id: variable_config
  parameters:
    config_file: configFile
    option: symbol_sync_loop_bandwidth_ch800
    section: 4GFSK_CHANNELS
    type: real
    value: '0.015'
    writeback: None
  states: {}
- name: loop_bw_s
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,1,1,1
    label: Loop BW
    start: '0.0'
    step: '0.001'
    stop: 2.0*3.141592653589793*0.25
    value: '0.015'
  states: {state: disabled}
- name: loop_bw_s
  id: variable_config
  parameters:
    config_file: configFile
    option: symbol_sync_loop_bandwidth
    section: 2GFSK_CHANNELS
    type: real
    value: '0.015'
    writeback: None
  states: {}
- name: loop_damping_100_h
  id: variable_config
  parameters:
    config_file: configFile
    option: symbol_sync_loop_damping_ch100
    section: 4GFSK_CHANNELS
    type: real
    value: '1.4'
    writeback: None
  states: {}
- name: loop_damping_200_h
  id: variable_config
  parameters:
    config_file: configFile
    option: symbol_sync_loop_damping_ch200
    section: 4GFSK_CHANNELS
    type: real
    value: '1.4'
    writeback: None
  states: {}
- name: loop_damping_600_h
  id: variable_config
  parameters:
    config_file: configFile
    option: symbol_sync_loop_damping_ch600
    section: 4GFSK_CHANNELS
    type: real
    value: '1.4'
    writeback: None
  states: {}
- name: loop_damping_800_h
  id: variable_config
  parameters:
    config_file: configFile
    option: symbol_sync_loop_damping_ch800
    section: 4GFSK_CHANNELS
    type: real
    value: '1.4'
    writeback: None
  states: {}
- name: loop_damping_s
  id: variable_config
  parameters:
    config_file: configFile
    option: symbol_sync_loop_damping
    section: 2GFSK_CHANNELS
    type: real
    value: '1.4'
    writeback: None
  states: {}
- name: loop_damping_s
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,0,1,1
    label: Damping Factor
    start: '0.1'
    step: '0.1'
    stop: '5.0'
    value: '1.4'
  states: {state: disabled}
- name: message_debug
  id: variable_config
  parameters:
    config_file: multichannelSnifferConfig.conf
    option: individual_channel_log
    section: DEBUG_LOG
    type: bool
    value: 'False'
    writeback: None
  states: {}
- name: passband_end_100_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch100_passband_end_frequency
    section: 4GFSK_CHANNELS
    type: real
    value: 84e3
    writeback: None
  states: {}
- name: passband_end_200_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch200_passband_end_frequency
    section: 4GFSK_CHANNELS
    type: real
    value: 125e3
    writeback: None
  states: {}
- name: passband_end_600_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch600_passband_end_frequency
    section: 4GFSK_CHANNELS
    type: real
    value: 285e3
    writeback: None
  states: {}
- name: passband_end_800_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch800_passband_end_frequency
    section: 4GFSK_CHANNELS
    type: real
    value: 365e3
    writeback: None
  states: {}
- name: passband_end_s
  id: variable_config
  parameters:
    config_file: configFile
    option: channel_passband_end_frequency
    section: 2GFSK_CHANNELS
    type: real
    value: 39e3
    writeback: None
  states: {}
- name: qt_gui_display_time_after_symbolSink
  id: variable
  parameters:
    value: '32e-3'
  states: {}
- name: qt_gui_display_time_before_decimation
  id: variable
  parameters:
    value: '64e-3'
  states: {}
- name: qt_gui_display_time_before_symbolSink
  id: variable
  parameters:
    value: '64e-3'
  states: {}
- name: rssi_calib_offset_100_h
  id: variable_config
  parameters:
    config_file: configFile
    option: rssi_offset_calibration_ch100
    section: 4GFSK_CHANNELS
    type: real
    value: '-5.0'
    writeback: None
  states: {}
- name: rssi_calib_offset_200_h
  id: variable_config
  parameters:
    config_file: configFile
    option: rssi_offset_calibration_ch200
    section: 4GFSK_CHANNELS
    type: real
    value: '-5.0'
    writeback: None
  states: {}
- name: rssi_calib_offset_600_h
  id: variable_config
  parameters:
    config_file: configFile
    option: rssi_offset_calibration_ch600
    section: 4GFSK_CHANNELS
    type: real
    value: '-5.0'
    writeback: None
  states: {}
- name: rssi_calib_offset_800_h
  id: variable_config
  parameters:
    config_file: configFile
    option: rssi_offset_calibration_ch800
    section: 4GFSK_CHANNELS
    type: real
    value: '-5.0'
    writeback: None
  states: {}
- name: rssi_calib_offset_s
  id: variable_config
  parameters:
    config_file: configFile
    option: rssi_offset_calibration
    section: 2GFSK_CHANNELS
    type: real
    value: '-5.0'
    writeback: None
  states: {}
- name: samp_rate
  id: variable_config
  parameters:
    config_file: configFile
    option: sample_rate
    section: HW_SOURCE_CONFIG
    type: int
    value: '13000000'
    writeback: None
  states: {}
- name: samp_rate_demod_100_h
  id: variable_config
  parameters:
    config_file: configFile
    option: demodulation_sample_rate_ch100
    section: 4GFSK_CHANNELS
    type: int
    value: '260000'
    writeback: None
  states: {}
- name: samp_rate_demod_200_h
  id: variable_config
  parameters:
    config_file: configFile
    option: demodulation_sample_rate_ch200
    section: 4GFSK_CHANNELS
    type: int
    value: '325000'
    writeback: None
  states: {}
- name: samp_rate_demod_600_h
  id: variable_config
  parameters:
    config_file: configFile
    option: demodulation_sample_rate_ch600
    section: 4GFSK_CHANNELS
    type: int
    value: '650000'
    writeback: None
  states: {}
- name: samp_rate_demod_800_h
  id: variable_config
  parameters:
    config_file: configFile
    option: demodulation_sample_rate_ch800
    section: 4GFSK_CHANNELS
    type: int
    value: '812500'
    writeback: None
  states: {}
- name: samp_rate_demod_s
  id: variable_config
  parameters:
    config_file: configFile
    option: demodulation_sample_rate
    section: 2GFSK_CHANNELS
    type: int
    value: '100000'
    writeback: None
  states: {}
- name: squelchAlpha_100_h
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_alpha_ch100
    section: 4GFSK_CHANNELS
    type: real
    value: '0.3'
    writeback: None
  states: {}
- name: squelchAlpha_200_h
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_alpha_ch200
    section: 4GFSK_CHANNELS
    type: real
    value: '0.3'
    writeback: None
  states: {}
- name: squelchAlpha_600_h
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_alpha_ch600
    section: 4GFSK_CHANNELS
    type: real
    value: '0.3'
    writeback: None
  states: {}
- name: squelchAlpha_800_h
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_alpha_ch800
    section: 4GFSK_CHANNELS
    type: real
    value: '0.3'
    writeback: None
  states: {}
- name: squelchAlpha_s
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_alpha
    section: 2GFSK_CHANNELS
    type: real
    value: '0.3'
    writeback: None
  states: {}
- name: squelch_level_100_h
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_level_ch100
    section: 4GFSK_CHANNELS
    type: int
    value: '-58'
    writeback: None
  states: {}
- name: squelch_level_200_h
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_level_ch200
    section: 4GFSK_CHANNELS
    type: int
    value: '-50'
    writeback: None
  states: {}
- name: squelch_level_600_h
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_level_ch600
    section: 4GFSK_CHANNELS
    type: int
    value: '-50'
    writeback: None
  states: {}
- name: squelch_level_800_h
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_level_ch800
    section: 4GFSK_CHANNELS
    type: int
    value: '-50'
    writeback: None
  states: {}
- name: squelch_level_s
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_level
    section: 2GFSK_CHANNELS
    type: int
    value: '-62'
    writeback: None
  states: {}
- name: squelch_ramp_100_h
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_ramp_ch100
    section: 4GFSK_CHANNELS
    type: int
    value: '8'
    writeback: None
  states: {}
- name: squelch_ramp_200_h
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_ramp_ch200
    section: 4GFSK_CHANNELS
    type: int
    value: '8'
    writeback: None
  states: {}
- name: squelch_ramp_600_h
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_ramp_ch600
    section: 4GFSK_CHANNELS
    type: int
    value: '8'
    writeback: None
  states: {}
- name: squelch_ramp_800_h
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_ramp_ch800
    section: 4GFSK_CHANNELS
    type: int
    value: '8'
    writeback: None
  states: {}
- name: squelch_ramp_s
  id: variable_config
  parameters:
    config_file: configFile
    option: squelch_ramp
    section: 2GFSK_CHANNELS
    type: int
    value: '8'
    writeback: None
  states: {}
- name: stop_band_attenuation_dB_100_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch100_stopband_attenuation
    section: 4GFSK_CHANNELS
    type: int
    value: '96'
    writeback: None
  states: {}
- name: stop_band_attenuation_dB_200_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch200_stopband_attenuation
    section: 4GFSK_CHANNELS
    type: int
    value: '96'
    writeback: None
  states: {}
- name: stop_band_attenuation_dB_600_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch600_stopband_attenuation
    section: 4GFSK_CHANNELS
    type: int
    value: '96'
    writeback: None
  states: {}
- name: stop_band_attenuation_dB_800_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch800_stopband_attenuation
    section: 4GFSK_CHANNELS
    type: int
    value: '96'
    writeback: None
  states: {}
- name: stop_band_attenuation_dB_s
  id: variable_config
  parameters:
    config_file: configFile
    option: channel_stopband_attenuation
    section: 2GFSK_CHANNELS
    type: int
    value: '96'
    writeback: None
  states: {}
- name: stopband_start_100_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch100_stopband_start_frequency
    section: 4GFSK_CHANNELS
    type: real
    value: 90e3
    writeback: None
  states: {}
- name: stopband_start_200_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch200_stopband_start_frequency
    section: 4GFSK_CHANNELS
    type: real
    value: 135e3
    writeback: None
  states: {}
- name: stopband_start_600_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch600_stopband_start_frequency
    section: 4GFSK_CHANNELS
    type: real
    value: 295e3
    writeback: None
  states: {}
- name: stopband_start_800_h
  id: variable_config
  parameters:
    config_file: configFile
    option: ch800_stopband_start_frequency
    section: 4GFSK_CHANNELS
    type: real
    value: 375e3
    writeback: None
  states: {}
- name: stopband_start_s
  id: variable_config
  parameters:
    config_file: configFile
    option: channel_stopband_start_frequency
    section: 2GFSK_CHANNELS
    type: real
    value: 49e3
    writeback: None
  states: {}
- name: tcp_host_ipv4_address
  id: variable_config
  parameters:
    config_file: multichannelSnifferConfig.conf
    option: ipv4_address
    section: TCP_SERVER
    type: string
    value: '''127.0.0.1'''
    writeback: None
  states: {}
- name: tcp_host_port_number
  id: variable_config
  parameters:
    config_file: multichannelSnifferConfig.conf
    option: port_number
    section: TCP_SERVER
    type: int
    value: '1337'
    writeback: None
  states: {}
- name: ted_gain_100_h
  id: variable_config
  parameters:
    config_file: configFile
    option: timing_error_detector_gain_ch100
    section: 4GFSK_CHANNELS
    type: real
    value: '1.0'
    writeback: None
  states: {}
- name: ted_gain_200_h
  id: variable_config
  parameters:
    config_file: configFile
    option: timing_error_detector_gain_ch200
    section: 4GFSK_CHANNELS
    type: real
    value: '1.0'
    writeback: None
  states: {}
- name: ted_gain_600_h
  id: variable_config
  parameters:
    config_file: configFile
    option: timing_error_detector_gain_ch600
    section: 4GFSK_CHANNELS
    type: real
    value: '1.0'
    writeback: None
  states: {}
- name: ted_gain_800_h
  id: variable_config
  parameters:
    config_file: configFile
    option: timing_error_detector_gain_ch800
    section: 4GFSK_CHANNELS
    type: real
    value: '1.0'
    writeback: None
  states: {}
- name: ted_gain_s
  id: variable_config
  parameters:
    config_file: configFile
    option: timing_error_detector_gain
    section: 2GFSK_CHANNELS
    type: real
    value: '1.0'
    writeback: None
  states: {}
- name: ted_gain_s
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,0,1,1
    label: TED Gain
    start: '0.05'
    step: '0.01'
    stop: '5.0'
    value: '1'
  states: {state: disabled}
- name: ted_max_deviation_100_h
  id: variable_config
  parameters:
    config_file: configFile
    option: timing_error_detector_max_deviation_ch100
    section: 4GFSK_CHANNELS
    type: real
    value: '1.5'
    writeback: None
  states: {}
- name: ted_max_deviation_200_h
  id: variable_config
  parameters:
    config_file: configFile
    option: timing_error_detector_max_deviation_ch200
    section: 4GFSK_CHANNELS
    type: real
    value: '1.5'
    writeback: None
  states: {}
- name: ted_max_deviation_600_h
  id: variable_config
  parameters:
    config_file: configFile
    option: timing_error_detector_max_deviation_ch600
    section: 4GFSK_CHANNELS
    type: real
    value: '1.5'
    writeback: None
  states: {}
- name: ted_max_deviation_800_h
  id: variable_config
  parameters:
    config_file: configFile
    option: timing_error_detector_max_deviation_ch800
    section: 4GFSK_CHANNELS
    type: real
    value: '1.5'
    writeback: None
  states: {}
- name: ted_max_deviation_s
  id: variable_config
  parameters:
    config_file: configFile
    option: timing_error_detector_max_deviation
    section: 2GFSK_CHANNELS
    type: real
    value: '1.5'
    writeback: None
  states: {}
- name: vga_gain
  id: variable_config
  parameters:
    config_file: configFile
    option: pre_adc_amplifier_gain
    section: HW_SOURCE_CONFIG
    type: int
    value: '0'
    writeback: None
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: for separing traces
    const: '-2'
    type: float
  states: {state: disabled}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_2_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_0_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_0_0_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_0_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_0_0_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_0_0_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_1_0_0_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_0_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_0_0_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_0_0_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_10
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_10_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_10_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_10_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_10_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_10_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_10_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_10_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_10_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_1_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_1_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_1_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_1_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_1_0_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_1_0_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_1_0_2_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_1_0_2_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_1_0_1_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_2_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_2_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_2_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_2_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_2_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_2_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_2_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_2_0_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_2_0_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_3_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_3_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_3_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_3_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_3_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_3_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_3_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_3_0_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_3_0_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_4_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_4_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_4_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_4_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_4_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_4_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_4_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_4_0_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_4_0_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_5_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_5_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_5_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_5_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_5_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_5_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_5_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_5_0_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_5_0_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_6_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_6_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_6_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_6_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_6_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_6_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_6_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_6_0_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_6_0_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_7_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_7_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_7_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_7_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_7_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_7_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_7_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_7_0_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_7_0_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_8_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_8_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_8_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_8_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_8_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_8_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_8_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_8_0_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_8_0_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_9_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_9_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_9_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_9_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_9_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_9_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_9_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_9_0_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_0_9_0_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_1_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_2_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_2_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_2_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_2_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_2_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_2_1_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_2_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2_2_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Recorded samples player for testing
    file: C:\Users\fnpfa\Desktop\GNU_Mikrodust_comparission_tests\Data_for_test_documented_on_confluence\spectrumRecord1.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: HW Source params
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Source scopes
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Scopes time ranges
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: TCP Server
  states: {}
- name: note_0_0_0_0_0
  id: note
  parameters:
    note: Individual channel log
  states: {}
- name: note_0_0_0_0_0_0
  id: note
  parameters:
    note: Global log
  states: {}
- name: note_0_0_0_0_1
  id: note
  parameters:
    note: Python Snippets
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Demodulators
  states: {}
- name: note_0_0_2
  id: note
  parameters:
    note: Channel scopes
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Modulation parameters
  states: {}
- name: note_0_1_0_0
  id: note
  parameters:
    note: Symbol Syncronizer
  states: {}
- name: note_0_1_0_0_0
  id: note
  parameters:
    note: Squelch
  states: {}
- name: note_0_1_0_0_0_0
  id: note
  parameters:
    note: 2GFSK Channels freqs
  states: {}
- name: note_0_1_0_0_0_0_0
  id: note
  parameters:
    note: Channel filters
  states: {}
- name: note_0_1_0_0_0_0_0_0
  id: note
  parameters:
    note: Channel filters 100
  states: {}
- name: note_0_1_0_0_0_0_0_0_0
  id: note
  parameters:
    note: Channel filters 600
  states: {}
- name: note_0_1_0_0_0_0_0_0_0_0
  id: note
  parameters:
    note: Channel filters 800
  states: {}
- name: note_0_1_0_0_0_0_0_0_0_1
  id: note
  parameters:
    note: Channel filters 200
  states: {}
- name: note_0_1_0_0_0_0_1
  id: note
  parameters:
    note: H. Speed Channels freqs
  states: {}
- name: note_0_1_0_0_0_0_2
  id: note
  parameters:
    note: 2GFSK Channels enables
  states: {}
- name: note_0_1_0_0_0_0_2_0
  id: note
  parameters:
    note: 4GFSK Channels enables
  states: {}
- name: note_0_1_0_0_0_0_2_1
  id: note
  parameters:
    note: 2GFSK Override ch.#
  states: {}
- name: note_0_1_0_0_0_0_2_1_0
  id: note
  parameters:
    note: 'Overrides ch. # (LatAm)'
  states: {}
- name: note_0_1_0_0_0_1
  id: note
  parameters:
    note: Squelch 100
  states: {}
- name: note_0_1_0_0_0_1_0
  id: note
  parameters:
    note: Squelch 200
  states: {}
- name: note_0_1_0_0_0_1_1
  id: note
  parameters:
    note: Squelch 600
  states: {}
- name: note_0_1_0_0_0_1_2
  id: note
  parameters:
    note: Squelch 800
  states: {}
- name: note_0_1_0_0_0_2
  id: note
  parameters:
    note: DC block
  states: {}
- name: note_0_1_0_0_0_2_0
  id: note
  parameters:
    note: RSSI Calibration
  states: {}
- name: note_0_1_0_0_0_2_0_0
  id: note
  parameters:
    note: RSSI Calib. 100
  states: {}
- name: note_0_1_0_0_0_2_0_0_0
  id: note
  parameters:
    note: RSSI Calib. 200
  states: {}
- name: note_0_1_0_0_0_2_0_0_1
  id: note
  parameters:
    note: RSSI Calib. 600
  states: {}
- name: note_0_1_0_0_0_2_0_0_2
  id: note
  parameters:
    note: RSSI Calib. 800
  states: {}
- name: note_0_1_0_0_0_2_1
  id: note
  parameters:
    note: DC block 100
  states: {}
- name: note_0_1_0_0_0_2_1_0
  id: note
  parameters:
    note: DC block 200
  states: {}
- name: note_0_1_0_0_0_2_1_1
  id: note
  parameters:
    note: DC block 800
  states: {}
- name: note_0_1_0_0_0_2_1_2
  id: note
  parameters:
    note: DC block 600
  states: {}
- name: note_0_1_0_0_1
  id: note
  parameters:
    note: Symbol Sync 100
  states: {}
- name: note_0_1_0_0_1_0
  id: note
  parameters:
    note: Symbol Sync 200
  states: {}
- name: note_0_1_0_0_1_1
  id: note
  parameters:
    note: Symbol Sync 600
  states: {}
- name: note_0_1_0_0_1_2
  id: note
  parameters:
    note: Symbol Sync 800
  states: {}
- name: note_0_1_1
  id: note
  parameters:
    note: Baseband signal params
  states: {}
- name: note_0_1_1_0
  id: note
  parameters:
    note: '2-GFSK CHANNELS PARAMS '
  states: {}
- name: note_0_1_1_0_0
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_0
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_0_0
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_0_0_0
  id: note
  parameters:
    note: _____END_____________
  states: {}
- name: note_0_1_1_0_0_0_0_0_0
  id: note
  parameters:
    note: _____END_____________
  states: {}
- name: note_0_1_1_0_0_0_0_1
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_0_0_1_0
  id: note
  parameters:
    note: Channel decoding
  states: {}
- name: note_0_1_1_0_0_0_1
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_0_1_0
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_0_1_0_1
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_0_1_0_1_0
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_0_1_0_1_0_0
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_1
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_1_0
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_1_1
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_1_2
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_2
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_2_0
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_2_0_1
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_2_0_1_0
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_2_0_1_0_0
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_3
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_0_4
  id: note
  parameters:
    note: '______________________'
  states: {}
- name: note_0_1_1_0_1
  id: note
  parameters:
    note: '4-GFSK CHANNELS PARAMS '
  states: {}
- name: note_0_1_1_0_1_0
  id: note
  parameters:
    note: '4-GFSK CHANNELS '
  states: {}
- name: note_0_1_1_0_1_0_1
  id: note
  parameters:
    note: '2-GFSK CHANNELS '
  states: {}
- name: note_0_1_1_0_1_0_1_0
  id: note
  parameters:
    note: SAMPLE SOURCE
  states: {}
- name: note_0_1_1_0_1_0_1_0_0
  id: note
  parameters:
    note: TCP_SERVER
  states: {}
- name: note_0_1_1_1
  id: note
  parameters:
    note: Baseband signal params
  states: {}
- name: note_0_1_1_1_0
  id: note
  parameters:
    note: H. Speed bitrates
  states: {}
- name: note_0_1_2
  id: note
  parameters:
    note: Freq. deviations
  states: {}
- name: note_0_1_2_0
  id: note
  parameters:
    note: Demod. sample rate
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: HW Source gains
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '0'
    bw0: 1.75e6
    freq0: lo_osc_freq+lo_osc_freq_error_correction
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 15,0,1,1
    label1: T_inst
    label2: T_avg
    name: '"Symbol Sync Output"'
    nconnections: '2'
    type: float
    unit1: sambles/bit
    unit2: samples/bit
    update_time: '0.001'
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 15,0,1,1
    label1: T_inst
    label2: T_avg
    name: '"Symbol Sync Output"'
    nconnections: '2'
    type: float
    unit1: sambles/bit
    unit2: samples/bit
    update_time: '0.001'
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_demod_s
    fc: '0'
    fftsize: '8192'
    gui_hint: (1,1,1,1)
    name: '"Xlating FIR Filter Output"'
    rate: '60'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: lo_osc_freq
    fftsize: '8192'
    gui_hint: (1,0,1,1)
    name: '"Osmocom/Soapy HW Output Spectrum"'
    rate: '60'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_demod_100_h
    fc: '0'
    fftsize: '8192'
    gui_hint: (1,1,1,1)
    name: '"Xlating FIR Filter Output"'
    rate: '60'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 12,1,1,1
    label1: Bitstream
    label2: Error
    label3: T_inst
    label4: T_avg
    name: '"Symbol Sync Output"'
    nconnections: '4'
    size: int((bitrate_s)*qt_gui_display_time_after_symbolSink)
    srate: bitrate_s
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
    ymax: '9'
    ymin: '-9'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 16,1,1,1
    label1: Bitstream
    label2: Power
    label3: Freq. error
    name: '"Average power and frequency error visualizer"'
    nconnections: '3'
    size: int((bitrate_s)*qt_gui_display_time_after_symbolSink)
    srate: bitrate_s
    tr_delay: '8e-3'
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 16,1,1,1
    label1: Bitstream
    label2: Power
    label3: Freq. error
    name: '"Average power and frequency error visualizer"'
    nconnections: '3'
    size: int((ch100Bitrate_h)*qt_gui_display_time_after_symbolSink)
    srate: ch100Bitrate_h
    tr_delay: '8e-3'
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 12,1,1,1
    label1: Bitstream
    label2: Error
    label3: T_inst
    label4: T_avg
    marker1: '0'
    name: '"Symbol Sync Output"'
    nconnections: '4'
    size: int((ch100Bitrate_h/2)*qt_gui_display_time_after_symbolSink)
    srate: ch100Bitrate_h/2
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
    ymax: '9'
    ymin: '-9'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    color1: red
    color2: blue
    ctrlpanel: 'True'
    grid: 'True'
    label1: Bytes out
    label2: Bits out
    marker1: '0'
    marker2: '0'
    name: '"Symbol Sync Data Output"'
    nconnections: '2'
    size: int((ch100Bitrate_h)*qt_gui_display_time_after_symbolSink)
    srate: ch100Bitrate_h
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
    ymax: '9'
    ymin: '-9'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 16,0,1,1
    marker1: '0'
    name: '"Correlator output"'
    size: int((bitrate_s)*qt_gui_display_time_after_symbolSink)
    srate: bitrate_s
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
    ymax: '1.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 12,0,1,1
    name: '"LF AGC output"'
    size: int((samp_rate_demod_s)*qt_gui_display_time_before_symbolSink)
    srate: samp_rate_demod_s
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 6,1,1,1
    label1: In Phase (Re)
    label2: Quadrature (Im)
    name: '"Squelch output"'
    size: int((samp_rate_demod_s)*qt_gui_display_time_before_symbolSink)
    srate: samp_rate_demod_s
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.001'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: In Phase (Re)
    label2: Quadrature (Im)
    name: '"Osmocom/Soapy HW Output"'
    size: int(qt_gui_display_time_before_decimation*samp_rate)
    srate: samp_rate
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.001'
    ymax: '1.2'
    ymin: '-1.2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: In Phase (Re)
    label2: Quadrature (Im)
    name: '"Xlating FIR Filter Output"'
    size: int((samp_rate_demod_s)*qt_gui_display_time_before_symbolSink)
    srate: samp_rate_demod_s
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.001'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: In Phase (Re)
    label2: Quadrature (Im)
    name: '"Xlating FIR Filter Output"'
    size: int((samp_rate_demod_100_h)*qt_gui_display_time_before_symbolSink)
    srate: samp_rate_demod_100_h
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.001'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_0_2
  id: qtgui_time_sink_x
  parameters:
    color2: green
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 6,1,1,1
    label1: In Phase (Re)
    label2: Quadrature (Im)
    name: '"Squelch output"'
    size: int((samp_rate_demod_100_h)*qt_gui_display_time_before_symbolSink)
    srate: samp_rate_demod_100_h
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.001'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 8,0,1,1
    name: '"Quadrature Demod output"'
    size: int((samp_rate_demod_s)*qt_gui_display_time_before_symbolSink)
    srate: samp_rate_demod_s
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 8,1,1,1
    name: '"LF DC block output"'
    size: int((samp_rate_demod_s)*qt_gui_display_time_before_symbolSink)
    srate: samp_rate_demod_s
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 8,1,1,1
    name: '"LF DC block output"'
    size: int((samp_rate_demod_100_h)*qt_gui_display_time_before_symbolSink)
    srate: samp_rate_demod_100_h
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_1_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 8,0,1,1
    name: '"Quadrature Demod output"'
    size: int((samp_rate_demod_100_h)*qt_gui_display_time_before_symbolSink)
    srate: samp_rate_demod_100_h
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 12,0,1,1
    name: '"LF AGC output"'
    size: int((samp_rate_demod_100_h)*qt_gui_display_time_before_symbolSink)
    srate: samp_rate_demod_100_h
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 16,0,1,1
    marker1: '0'
    name: '"Correlator output"'
    size: int((ch100Bitrate_h)*qt_gui_display_time_after_symbolSink)
    srate: ch100Bitrate_h
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
    ymax: '1.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import time
      # import socket

      print('The Sniffer has been stopped.')

      msg = "tcpCloseClientConection"

      self.epy_block_2.tcpQueue.put(msg, block=False)
      time.sleep(2)

      self.epy_block_2.tcpSocket.close()

      print('End of the execution.')

      # self.stop()
      sys.exit(0)
    priority: '1'
    section: main_after_stop
  states: {state: disabled}
- name: snippet_0_0
  id: snippet
  parameters:
    code: |-
      print('End of the execution.')
      sys.exit(0)
    priority: '1'
    section: main_after_stop
  states: {}
- name: snippet_0_0_0
  id: snippet
  parameters:
    code: |-
      # Starts the server at "Verisure TCP Server Sink" block
      self.verisure_tcp_server_sink.start_TCP_server()

      print("Started TCP server at specified adress and port in multichannelSnifferConfig.conf file:")
      print(self.tcp_host_ipv4_address,":",self.tcp_host_port_number)
      print("Starting to receive frames.")
    priority: '1'
    section: main_after_start
  states: {}
- name: snippet_1
  id: snippet
  parameters:
    code: |-
      # This snippet edits the property "log_level" from the
      # section "LOG" of the following config file:
      # <prefix>/etc/gnuradio/conf.d/gnuradio-runtime.conf
      # in order to change the level of logging from DEBUG (default)
      # to FATAL and thus preventing polluting the console with
      # logging info from GR blocks.
      # For more info read:
      # https://wiki.gnuradio.org/index.php?title=Logging
      # https://wiki.gnuradio.org/index.php?title=Configuration_Files
      # https://www.gnuradio.org/doc/doxygen/classgr_1_1prefs.html
      # Note that the log levels can be:
      # DEBUG, INFO, WARN, TRACE, ERROR, ALERT, CRIT, FATAL, EMERG

      p = gr.prefs() # loads propiertys
      p.set_string("LOG","log_level","EMERG") # sets the propiery
      try:
      	p.save() # saves settings to ${HOME}/.gnuradio/config.conf
      except:
      	pass
      print("Verisure Safety Multichannel Sniffer has been initialized successfully.")
      print("The current channel setup in use is:",self.configFile)
    priority: '1'
    section: main_after_init
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: lna_on
    bandwidth: antialiass_filter_bw
    center_freq: lo_osc_freq+lo_osc_freq_error_correction
    comment: HackRF
    gain: if_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}
- name: verisure2GFSKRadioChannelToDataMessage_0
  id: verisure2GFSKRadioChannelToDataMessage
  parameters:
    bitrate: bitrate_s
    ch_enable: ch1enable
    ch_number: ch1_number_s
    crc_key: crc_key
    crc_polynomial: crc_polynomial
    debug_log: message_debug
    debug_log_verbosity: high_verbosity_debug
    demod_dc_block_time: demod_dc_block_time_s
    dewhitening_key: dewhitening_key
    fsk_deviation: fsk_deviation_s
    lo_osc_freq: lo_osc_freq
    loop_bw: loop_bw_s
    loop_damping: loop_damping_s
    passband_end: passband_end_s
    power_offset_calib: rssi_calib_offset_s
    samp_rate: samp_rate
    samp_rate_demod: samp_rate_demod_s
    selected_ch_freq: ch1freq_s
    squelchAlpha: squelchAlpha_s
    squelch_level: squelch_level_s
    squelch_ramp: squelch_ramp_s
    stop_band_attenuation_dB: stop_band_attenuation_dB_s
    stopband_start: stopband_start_s
    ted_gain: ted_gain_s
    ted_max_deviation: ted_max_deviation_s
  states: {}
- name: verisure2GFSKRadioChannelToDataMessage_0_0
  id: verisure2GFSKRadioChannelToDataMessage
  parameters:
    bitrate: bitrate_s
    ch_enable: ch2enable
    ch_number: ch2_number_s
    crc_key: crc_key
    crc_polynomial: crc_polynomial
    debug_log: message_debug
    debug_log_verbosity: high_verbosity_debug
    demod_dc_block_time: demod_dc_block_time_s
    dewhitening_key: dewhitening_key
    fsk_deviation: fsk_deviation_s
    lo_osc_freq: lo_osc_freq
    loop_bw: loop_bw_s
    loop_damping: loop_damping_s
    passband_end: passband_end_s
    power_offset_calib: rssi_calib_offset_s
    samp_rate: samp_rate
    samp_rate_demod: samp_rate_demod_s
    selected_ch_freq: ch2freq_s
    squelchAlpha: squelchAlpha_s
    squelch_level: squelch_level_s
    squelch_ramp: squelch_ramp_s
    stop_band_attenuation_dB: stop_band_attenuation_dB_s
    stopband_start: stopband_start_s
    ted_gain: ted_gain_s
    ted_max_deviation: ted_max_deviation_s
  states: {}
- name: verisure2GFSKRadioChannelToDataMessage_0_1
  id: verisure2GFSKRadioChannelToDataMessage
  parameters:
    bitrate: bitrate_s
    ch_enable: ch3enable
    ch_number: ch3_number_s
    crc_key: crc_key
    crc_polynomial: crc_polynomial
    debug_log: message_debug
    debug_log_verbosity: high_verbosity_debug
    demod_dc_block_time: demod_dc_block_time_s
    dewhitening_key: dewhitening_key
    fsk_deviation: fsk_deviation_s
    lo_osc_freq: lo_osc_freq
    loop_bw: loop_bw_s
    loop_damping: loop_damping_s
    passband_end: passband_end_s
    power_offset_calib: rssi_calib_offset_s
    samp_rate: samp_rate
    samp_rate_demod: samp_rate_demod_s
    selected_ch_freq: ch3freq_s
    squelchAlpha: squelchAlpha_s
    squelch_level: squelch_level_s
    squelch_ramp: squelch_ramp_s
    stop_band_attenuation_dB: stop_band_attenuation_dB_s
    stopband_start: stopband_start_s
    ted_gain: ted_gain_s
    ted_max_deviation: ted_max_deviation_s
  states: {}
- name: verisure2GFSKRadioChannelToDataMessage_0_2
  id: verisure2GFSKRadioChannelToDataMessage
  parameters:
    bitrate: bitrate_s
    ch_enable: ch4enable
    ch_number: ch4_number_s
    crc_key: crc_key
    crc_polynomial: crc_polynomial
    debug_log: message_debug
    debug_log_verbosity: high_verbosity_debug
    demod_dc_block_time: demod_dc_block_time_s
    dewhitening_key: dewhitening_key
    fsk_deviation: fsk_deviation_s
    lo_osc_freq: lo_osc_freq
    loop_bw: loop_bw_s
    loop_damping: loop_damping_s
    passband_end: passband_end_s
    power_offset_calib: rssi_calib_offset_s
    samp_rate: samp_rate
    samp_rate_demod: samp_rate_demod_s
    selected_ch_freq: ch4freq_s
    squelchAlpha: squelchAlpha_s
    squelch_level: squelch_level_s
    squelch_ramp: squelch_ramp_s
    stop_band_attenuation_dB: stop_band_attenuation_dB_s
    stopband_start: stopband_start_s
    ted_gain: ted_gain_s
    ted_max_deviation: ted_max_deviation_s
  states: {}
- name: verisure2GFSKRadioChannelToDataMessage_0_3
  id: verisure2GFSKRadioChannelToDataMessage
  parameters:
    bitrate: bitrate_s
    ch_enable: ch5enable
    ch_number: ch5_number_s
    crc_key: crc_key
    crc_polynomial: crc_polynomial
    debug_log: message_debug
    debug_log_verbosity: high_verbosity_debug
    demod_dc_block_time: demod_dc_block_time_s
    dewhitening_key: dewhitening_key
    fsk_deviation: fsk_deviation_s
    lo_osc_freq: lo_osc_freq
    loop_bw: loop_bw_s
    loop_damping: loop_damping_s
    passband_end: passband_end_s
    power_offset_calib: rssi_calib_offset_s
    samp_rate: samp_rate
    samp_rate_demod: samp_rate_demod_s
    selected_ch_freq: ch5freq_s
    squelchAlpha: squelchAlpha_s
    squelch_level: squelch_level_s
    squelch_ramp: squelch_ramp_s
    stop_band_attenuation_dB: stop_band_attenuation_dB_s
    stopband_start: stopband_start_s
    ted_gain: ted_gain_s
    ted_max_deviation: ted_max_deviation_s
  states: {}
- name: verisure4GFSKRadioChannelToDataMessage_0
  id: verisure4GFSKRadioChannelToDataMessage
  parameters:
    bitrate: ch100Bitrate_h
    ch_enable: ch100enable
    ch_number: '10'
    comment: HS100 (ch.10)
    crc_key: crc_key
    crc_polynomial: crc_polynomial
    debug_log: message_debug
    debug_log_verbosity: high_verbosity_debug
    demod_dc_block_time: demod_dc_block_time_100_h
    dewhitening_key: dewhitening_key
    fsk_deviation: fsk_deviation_100_h
    lo_osc_freq: lo_osc_freq
    loop_bw: loop_bw_100_h
    loop_damping: loop_damping_100_h
    passband_end: passband_end_100_h
    power_offset_calib: rssi_calib_offset_100_h
    samp_rate: samp_rate
    samp_rate_demod: samp_rate_demod_100_h
    selected_ch_freq: ch100freq_h
    squelchAlpha: squelchAlpha_100_h
    squelch_level: squelch_level_100_h
    squelch_ramp: squelch_ramp_100_h
    stop_band_attenuation_dB: stop_band_attenuation_dB_100_h
    stopband_start: stopband_start_100_h
    ted_gain: ted_gain_100_h
    ted_max_deviation: ted_max_deviation_100_h
  states: {}
- name: verisure4GFSKRadioChannelToDataMessage_0_0
  id: verisure4GFSKRadioChannelToDataMessage
  parameters:
    bitrate: ch200Bitrate_h
    ch_enable: ch200enable
    ch_number: '11'
    comment: HS200 (ch.11)
    crc_key: crc_key
    crc_polynomial: crc_polynomial
    debug_log: message_debug
    debug_log_verbosity: high_verbosity_debug
    demod_dc_block_time: demod_dc_block_time_200_h
    dewhitening_key: dewhitening_key
    fsk_deviation: fsk_deviation_200_h
    lo_osc_freq: lo_osc_freq
    loop_bw: loop_bw_200_h
    loop_damping: loop_damping_200_h
    passband_end: passband_end_200_h
    power_offset_calib: rssi_calib_offset_200_h
    samp_rate: samp_rate
    samp_rate_demod: samp_rate_demod_200_h
    selected_ch_freq: ch200freq_h
    squelchAlpha: squelchAlpha_200_h
    squelch_level: squelch_level_200_h
    squelch_ramp: squelch_ramp_200_h
    stop_band_attenuation_dB: stop_band_attenuation_dB_200_h
    stopband_start: stopband_start_200_h
    ted_gain: ted_gain_200_h
    ted_max_deviation: ted_max_deviation_200_h
  states: {}
- name: verisure4GFSKRadioChannelToDataMessage_0_0_0
  id: verisure4GFSKRadioChannelToDataMessage
  parameters:
    bitrate: ch600Bitrate_h
    ch_enable: ch600enable
    ch_number: '12'
    comment: HS600 (ch.12)
    crc_key: crc_key
    crc_polynomial: crc_polynomial
    debug_log: message_debug
    debug_log_verbosity: high_verbosity_debug
    demod_dc_block_time: demod_dc_block_time_600_h
    dewhitening_key: dewhitening_key
    fsk_deviation: fsk_deviation_600_h
    lo_osc_freq: lo_osc_freq
    loop_bw: loop_bw_600_h
    loop_damping: loop_damping_600_h
    passband_end: passband_end_600_h
    power_offset_calib: rssi_calib_offset_600_h
    samp_rate: samp_rate
    samp_rate_demod: samp_rate_demod_600_h
    selected_ch_freq: ch600freq_h
    squelchAlpha: squelchAlpha_600_h
    squelch_level: squelch_level_600_h
    squelch_ramp: squelch_ramp_600_h
    stop_band_attenuation_dB: stop_band_attenuation_dB_600_h
    stopband_start: stopband_start_600_h
    ted_gain: ted_gain_600_h
    ted_max_deviation: ted_max_deviation_600_h
  states: {}
- name: verisure4GFSKRadioChannelToDataMessage_0_0_0_0
  id: verisure4GFSKRadioChannelToDataMessage
  parameters:
    bitrate: ch800Bitrate_h
    ch_enable: ch800enable
    ch_number: '13'
    comment: HS800 (ch.13)
    crc_key: crc_key
    crc_polynomial: crc_polynomial
    debug_log: message_debug
    debug_log_verbosity: high_verbosity_debug
    demod_dc_block_time: demod_dc_block_time_800_h
    dewhitening_key: dewhitening_key
    fsk_deviation: fsk_deviation_800_h
    lo_osc_freq: lo_osc_freq
    loop_bw: loop_bw_800_h
    loop_damping: loop_damping_800_h
    passband_end: passband_end_800_h
    power_offset_calib: rssi_calib_offset_800_h
    samp_rate: samp_rate
    samp_rate_demod: samp_rate_demod_800_h
    selected_ch_freq: ch800freq_h
    squelchAlpha: squelchAlpha_800_h
    squelch_level: squelch_level_800_h
    squelch_ramp: squelch_ramp_800_h
    stop_band_attenuation_dB: stop_band_attenuation_dB_800_h
    stopband_start: stopband_start_800_h
    ted_gain: ted_gain_800_h
    ted_max_deviation: ted_max_deviation_800_h
  states: {}
- name: verisure_tcp_server_sink
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from concurrent.futures.thread import _threads_queues
      import numpy as np
      from gnuradio import gr
      import pmt
      from datetime import datetime  # for timestamping recovering
      import socketserver  # for TCP server
      # import socket # for TCP server, deprecated
      import threading
      import queue
      import time


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Verisure TCP Server Sink block class"""

          # constructor for the block class:
          def __init__(self, block_Failed_CRC_frames=False, host='127.0.0.1', port=1337, server_mode=1,  debug_Log_Frame=False, high_Verbosity_Frame_Log=False,  debug_Log_Server=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Verisure TCP Server Sink',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )

              # input message port definition
              self.message_port_register_in(pmt.intern('pdu_in'))
              # asociation of handler function to input
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu)

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.hostIp = host
              self.portIp = port
              self.serverMode = server_mode
              self.blockFailedCRC = block_Failed_CRC_frames
              self.log = debug_Log_Frame
              self.highLogVerbosity = high_Verbosity_Frame_Log
              global logServer
              logServer = debug_Log_Server

              # maxQueueSize = 100 # optional param for queue.Queue()
              global tcpQueue  # thread-safe FIFO queue for sending data to the conection handler
              tcpQueue = queue.Queue()  # used when mode=0

              global threadsQueues
              # dictionary with key=threadId and value=(queue for a certain thread). Used when mode=1
              threadsQueues = {}

              if self.log:  # Debug Log
                  self.msgCount = 0
                  self.crcPassCount = 0
                  self.crcFailCount = 0

              """
              # TCP server init
              try:
                  self.tcpSocket = socket.socket(socket.AF_INET, socket.SOCK_STREAM) #AF_INET == IPv4, SCOKET_STREAM == TCP
                  if self.log: print ("Socket successfully created")
              except self.tcpSocket.error as err:
                  print ("socket creation failed with error %s" %(err))
              
              self.tcpSocket.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)
              
              self.tcpSocket.bind((hostIp, portIp)) #Binding == allocating a port number to a socket
              self.tcpSocket.listen(maxClients)

              # maxQueueSize = 100 # optional param for queue.Queue()
              self.tcpQueue = queue.Queue() # thread-safe FIFO queue for sending data to the server thread

              self.thread = threading.Thread(target=self.serverMain, args=(self.tcpSocket, self.tcpQueue))
              self.thread.start()
              """

          def handle_pdu(self, pdu):  # called when a pdu has been published to 'pdu_in' message port

              # access to the pdu parts:
              pduMetadataDictionary = pmt.car(pdu)  # first field of pdu extracted

              timeStamp = pmt.to_python(pmt.dict_ref(pduMetadataDictionary, pmt.intern(
                  "timestamp"), pmt.PMT_NIL))  # access to timestamp
              date_time = datetime.fromtimestamp(timeStamp)
              hh = date_time.hour
              mm = date_time.minute
              ss = date_time.second
              ms = int(date_time.microsecond * 0.001)

              power = pmt.to_python(pmt.dict_ref(pduMetadataDictionary, pmt.intern(
                  "power"), pmt.PMT_NIL))  # access to power
              # format to 3 digits whole number padding with non significative zeros
              rssi = "{:03.0f}".format(power)

              lqi = 1  # not suported by Verisure link frame. set as default

              freqError = pmt.to_python(pmt.dict_ref(pduMetadataDictionary, pmt.intern(
                  "freq_error"), pmt.PMT_NIL))  # access to power
              # format to 4 digits whole number padding with non significative zeros
              f_err = "{:04.0f}".format(freqError)

              channel = int(pmt.to_python(pmt.dict_ref(pduMetadataDictionary, pmt.intern(
                  "channel_number"), pmt.PMT_NIL)))  # access to channel number

              packetOk = int(pmt.to_python(pmt.dict_ref(pduMetadataDictionary, pmt.intern(
                  "crc_check"), pmt.PMT_NIL)))  # access to crc check

              payloadLength = pmt.to_python(pmt.dict_ref(pduMetadataDictionary, pmt.intern(
                  "payload_length"), pmt.PMT_NIL))  # access to payload_length key

              # second field of pdu extracted, which is the payload vector
              pduPayloadVector = pmt.to_python(pmt.cdr(pdu))
              tcpPayload = ""

              # converts payload list of bytes to a hex formatted string
              for i in range(0, len(pduPayloadVector) - 1):
                  tcpPayload = tcpPayload + \
                      "{:02X}".format(pduPayloadVector[i]) + " "
              tcpPayload = tcpPayload + \
                  "{:02X}".format(pduPayloadVector[len(
                      pduPayloadVector) - 1])  # last element

              msg = f"T{hh}:{mm}:{ss}.{ms},R{rssi},L{lqi},E{f_err},A{channel},C{packetOk},X0*{tcpPayload}#\n"

              if self.log:  # Debug
                  if self.msgCount == 0:
                      print('')  # spacer
                      print('')
                  if self.highLogVerbosity:
                      print('   Verisure TPC Server Sink message:')
                      print(' .----------------------------------------->')
                      print(' | Timestamp:', timeStamp)
                      print(' | Date and Time:', datetime.fromtimestamp(timeStamp))
                      print(' | |-> Hour:', hh)
                      print(' | |-> Minute:', mm)
                      print(' | |-> Second:', ss)
                      print(' | |-> Millisecond:', ms)
                      print(' | RSSI:', rssi)
                      print(' | LQI:', lqi)
                      print(' | Frequency Error in Hz:', f_err)
                      print(' | Channel Number:', channel)
                      print(' | CRC Check:', 'PASSED' if packetOk else 'FAILED')
                      print(' | Payload Length:', payloadLength)
                      print(' | Dewhitened Payload Data in DEC:', pduPayloadVector)
                      print(' | Payload Formatted String (HEX):', tcpPayload)
                      print(' | Final Formatted String:', msg + " |")
                      print(' | TCP Queue Size:', tcpQueue.qsize())
                      print(' *----------------------------------------->')
                  else:
                      self.msgCount += 1
                      if packetOk:
                          self.crcPassCount += 1
                      else:
                          self.crcFailCount += 1
                      passPercentage = (self.crcPassCount/(self.msgCount))*100
                      passPercentage = "{:03.4f}".format(passPercentage)
                      fixedDigitsMs = "{:03.0f}".format(ms)
                      print(f">{hh}:{mm}:{ss}.{fixedDigitsMs} | Ch = {channel} | RSSI = {rssi} | freq.Err = {f_err} Hz | PayloadLength = {payloadLength} | CRC Check: {'PASSED' if packetOk else 'FAILED'} | CRCPass = {passPercentage} % | (FailedCRC/AllReceivedCount) = {self.crcFailCount} / {self.msgCount} | Total Passed Count = {self.crcPassCount}")

              if self.blockFailedCRC:
                  if packetOk:
                      self.putPDUIntoQueues(msg)
              else:
                  self.putPDUIntoQueues(msg)

          def putPDUIntoQueues(self, pdu):

              if self.serverMode == 0:
                  global tcpQueue
                  # puts the pdu into queue for sending. If queue is full, raises Full exception
                  tcpQueue.put(pdu, block=False)
              elif self.serverMode == 1:
                  global threadsQueues
                  for threadId in threadsQueues.keys():  # puts the pdu in all queues of the dictionary "threadsQueues"
                      try:
                          # puts the pdu into queue for sending. If queue is full, raises Full exception
                          threadsQueues[threadId].put(pdu, block=False)
                      except:
                          pass

          # def set_channel(self, channel): # setter method for updating channel from the exterior (grc) -> Deprecated
          #    self.channel = channel

          def start_TCP_server(self):  # called at Python Snippet after start of the flowgraph
              server = None
              if self.serverMode == 0:  # only sends PDUs to last client connection
                  server = self.ThreadedTCPServer(
                      (self.hostIp, self.portIp), self.ThreadedTCPRequestHandlerSingleConnection)
              elif self.serverMode == 1:  # sends PDUs to all client connections
                  server = self.ThreadedTCPServer(
                      (self.hostIp, self.portIp), self.ThreadedTCPRequestHandlerMultipleConnections)
              else:
                  raise Exception('server_mode ', self.serverMode,
                                  ' is not defined.')

              # Start a thread with the server -- that thread will then start one
              # more thread for each request
              server_thread = threading.Thread(target=server.serve_forever)
              # Exit the server thread when the main thread terminates
              server_thread.daemon = True  # TODO read documentation
              server_thread.start()

              global allThreadIds
              allThreadIds = []  # ids list for conection threads
              global logServer
              if logServer:
                  print("Server loop running in thread:", server_thread.name)

          """
          def serverMain(self, socket, queue): # waits for conections and sends queued data
          
              try:
                  clientsocket, clientAddress = socket.accept() # stablishes conection. this method is blocking (waits for client to connect)
              except:
                  return # called for example if the sniffer is terminated before connecting to te client. kills the thread
              
              while True:
                  
                  msg = queue.get(block=True, timeout=None) # block if necessary until an item is available
                  if msg == "tcpCloseClientConection": # sent from the closing snippet in order to close the TCP socket
                      clientsocket.close()
                      print('Client TCP socket has been closed') 
                      socket.close() 
                      print('Server TCP socket has been closed') 
                  else: 
                      clientsocket.send(bytes(msg, "ascii")) # sends string to client
          """

          # Server auxiliar inner classes: ~~~~~~~~~~~~~~~~~~~~

          # inherits from socketserver.BaseRequestHandler
          class ThreadedTCPRequestHandlerSingleConnection(socketserver.BaseRequestHandler):
              """
              The request handler class for our server.
              It is instantiated once per connection to the server, and must
              override the handle() method to implement communication to the
              client.
              """
              # only sends PDUs to last client connection

              def handle(self):  # overrides default method which does nothing. Listens to a request and sends data
                  # self.request is the TCP socket connected to the client
                  current_thread = threading.current_thread()
                  thread_id = current_thread.ident
                  global allThreadIds
                  allThreadIds.append(thread_id)
                  # in sec. Allows other conection threads to end conection because of queue timeout
                  time.sleep(0.4)
                  global logServer
                  if logServer:
                      print('TCP Server: A new conection request has been received from {}'.format(
                          self.client_address))
                      print(
                          'TCP Server: That conection will be processed on thread {}'.format(thread_id))
                  global tcpQueue
                  while True:
                      # only send PDU if we are in last conection
                      if thread_id == allThreadIds[len(allThreadIds)-1]:

                          try:  # blocking version with timeout
                              # block if necessary until an item is available
                              msg = tcpQueue.get(block=True, timeout=0.1)
                              # if queue is empty for timeout seconds then an exception is raised and the while loop is started again
                              # this assures that the condition thread_id == allThreadIds[len(allThreadIds)-1] is met
                              # lowering the timeout increases CPU usage, but reduces risk of losing packets in changes of port
                              self.request.send(bytes(msg, "ascii"))
                          except:  # launched if tcpQueue is empty
                              pass
                      else:
                          return

          # inherits from socketserver.BaseRequestHandler
          class ThreadedTCPRequestHandlerMultipleConnections(socketserver.BaseRequestHandler):
              """
              The request handler class for our server.
              It is instantiated once per connection to the server, and must
              override the handle() method to implement communication to the
              client.
              """
              # sends PDUs to all client connections

              def handle(self):  # overrides default method which does nothing. Listens to a request and sends data
                  # self.request is the TCP socket connected to the client
                  current_thread = threading.current_thread()
                  thread_id = current_thread.ident

                  global threadsQueues
                  # thread-safe FIFO queue init. which is updated with incoming PDUs
                  threadsQueues[thread_id] = queue.Queue()

                  time.sleep(0.4)  # in sec.

                  global logServer
                  if logServer:
                      print('TCP Server: A new conection request has been received from {}'.format(
                          self.client_address))
                      print(
                          'TCP Server: That conection will be processed on thread {}'.format(thread_id))

                  while True:

                      try:  # blocking version
                          # block if necessary until an item is available
                          msg = threadsQueues[thread_id].get(
                              block=True, timeout=None)
                          # if queue is empty then an exception is raised and the while loop is started again
                          self.request.send(bytes(msg, "ascii"))
                      except:  # launched if tcpQueue is empty
                          pass

          class ThreadedTCPServer(socketserver.ThreadingMixIn, socketserver.TCPServer):
              pass
    block_Failed_CRC_frames: 'False'
    debug_Log_Frame: all_channel_log
    debug_Log_Server: debug_log_server
    high_Verbosity_Frame_Log: high_verbosity_all_channel_log
    host: tcp_host_ipv4_address
    port: tcp_host_port_number
    server_mode: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: 2gfsk_ch1_msg_out
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: 2gfsk_ch2_msg_out
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: 2gfsk_ch3_msg_out
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: 2gfsk_ch4_msg_out
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: 2gfsk_ch5_msg_out
  states: {}
- name: virtual_sink_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: 4gfsk_ch100_msg_out
  states: {}
- name: virtual_sink_0_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: 4gfsk_ch200_msg_out
  states: {}
- name: virtual_sink_0_0_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: 4gfsk_ch600_msg_out
  states: {}
- name: virtual_sink_0_0_0_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: 4gfsk_ch800_msg_out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: samples_to_2GFSK
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: samples_to_4GFSK
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: samples_to_2GFSK
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: samples_to_2GFSK
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: samples_to_2GFSK
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: samples_to_2GFSK
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: samples_to_2GFSK
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: 2gfsk_ch1_msg_out
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: 2gfsk_ch3_msg_out
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: 2gfsk_ch2_msg_out
  states: {}
- name: virtual_source_1_2
  id: virtual_source
  parameters:
    stream_id: 2gfsk_ch5_msg_out
  states: {}
- name: virtual_source_1_2_0
  id: virtual_source
  parameters:
    stream_id: 4gfsk_ch100_msg_out
  states: {}
- name: virtual_source_1_2_0_0
  id: virtual_source
  parameters:
    stream_id: 4gfsk_ch800_msg_out
  states: {}
- name: virtual_source_1_2_0_1
  id: virtual_source
  parameters:
    stream_id: 4gfsk_ch600_msg_out
  states: {}
- name: virtual_source_1_2_0_2
  id: virtual_source
  parameters:
    stream_id: 4gfsk_ch200_msg_out
  states: {}
- name: virtual_source_1_3
  id: virtual_source
  parameters:
    stream_id: 2gfsk_ch4_msg_out
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: samples_to_4GFSK
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: samples_to_4GFSK
  states: {}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: samples_to_4GFSK
  states: {}
- name: virtual_source_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: samples_to_4GFSK
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0_0_0_1_0, '1']
- [blocks_float_to_complex_0_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0_1_0_0_0_0, '0']
- [blocks_throttle_0, '0', virtual_sink_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0_0, '1']
- [osmosdr_source_0, '0', qtgui_sink_x_0_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0_0_1_0_0_0_0, '0']
- [osmosdr_source_0, '0', virtual_sink_1, '0']
- [osmosdr_source_0, '0', virtual_sink_2, '0']
- [soapy_hackrf_source_0, '0', qtgui_sink_x_0_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_time_sink_x_0_0_1_0_0_0_0, '0']
- [soapy_hackrf_source_0, '0', virtual_sink_1, '0']
- [soapy_hackrf_source_0, '0', virtual_sink_2, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '0', blocks_null_sink_2_2_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '0', qtgui_sink_x_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '0', qtgui_time_sink_x_0_0_1_0_0_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '1', blocks_null_sink_2_0_0_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '1', qtgui_time_sink_x_0_0_1_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '10', blocks_null_sink_2_1_0_2_0_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '10', qtgui_time_sink_x_0_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '11', blocks_null_sink_2_1_0_1_0_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '11', qtgui_time_sink_x_0_0_0_0, '1']
- [verisure2GFSKRadioChannelToDataMessage_0, '12', blocks_null_sink_2_1_0_1_0_1_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '12', qtgui_time_sink_x_0_0_0_0, '2']
- [verisure2GFSKRadioChannelToDataMessage_0, '2', blocks_null_sink_2_1_0_10_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '2', qtgui_time_sink_x_0_0_1_0_0_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '3', blocks_null_sink_2_1_0_8_0_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '3', qtgui_time_sink_x_0_0_1_0_0_1_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '4', blocks_null_sink_2_1_0_9_0_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '4', qtgui_time_sink_x_0_0_1_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '5', blocks_null_sink_2_1_0_7_0_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '5', qtgui_time_sink_x_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '6', blocks_null_sink_2_1_0_6_0_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '6', qtgui_time_sink_x_0_0_0, '1']
- [verisure2GFSKRadioChannelToDataMessage_0, '7', blocks_null_sink_2_1_0_5_0_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '7', qtgui_number_sink_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '7', qtgui_time_sink_x_0_0_0, '2']
- [verisure2GFSKRadioChannelToDataMessage_0, '8', blocks_null_sink_2_1_0_4_0_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '8', qtgui_number_sink_0, '1']
- [verisure2GFSKRadioChannelToDataMessage_0, '8', qtgui_time_sink_x_0_0_0, '3']
- [verisure2GFSKRadioChannelToDataMessage_0, '9', blocks_null_sink_2_1_0_3_0_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, '9', qtgui_time_sink_x_0_0_1_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0, message_out, virtual_sink_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_0, '0', blocks_null_sink_2_2, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_0, '1', blocks_null_sink_2_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_0, '10', blocks_null_sink_2_1_0_3_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_0, '11', blocks_null_sink_2_1_0_2_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_0, '12', blocks_null_sink_2_1_0_1_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_0, '2', blocks_null_sink_2_1_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_0, '3', blocks_null_sink_2_1_0_10, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_0, '4', blocks_null_sink_2_1_0_8_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_0, '5', blocks_null_sink_2_1_0_9_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_0, '6', blocks_null_sink_2_1_0_7_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_0, '7', blocks_null_sink_2_1_0_6_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_0, '8', blocks_null_sink_2_1_0_5_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_0, '9', blocks_null_sink_2_1_0_4_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_0, message_out, virtual_sink_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_1, '0', blocks_null_sink_2_2_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_1, '1', blocks_null_sink_2_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_1, '10', blocks_null_sink_2_1_0_3_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_1, '11', blocks_null_sink_2_1_0_2_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_1, '12', blocks_null_sink_2_1_0_1_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_1, '2', blocks_null_sink_2_1_0_1_0_0_1, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_1, '3', blocks_null_sink_2_1_0_10_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_1, '4', blocks_null_sink_2_1_0_8_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_1, '5', blocks_null_sink_2_1_0_9_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_1, '6', blocks_null_sink_2_1_0_7_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_1, '7', blocks_null_sink_2_1_0_6_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_1, '8', blocks_null_sink_2_1_0_5_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_1, '9', blocks_null_sink_2_1_0_4_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_1, message_out, virtual_sink_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_2, '0', blocks_null_sink_2_2_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_2, '1', blocks_null_sink_2_0_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_2, '10', blocks_null_sink_2_1_0_3_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_2, '11', blocks_null_sink_2_1_0_2_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_2, '12', blocks_null_sink_2_1_0_1_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_2, '2', blocks_null_sink_2_1_1_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_2, '3', blocks_null_sink_2_1_0_10_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_2, '4', blocks_null_sink_2_1_0_8_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_2, '5', blocks_null_sink_2_1_0_9_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_2, '6', blocks_null_sink_2_1_0_7_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_2, '7', blocks_null_sink_2_1_0_6_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_2, '8', blocks_null_sink_2_1_0_5_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_2, '9', blocks_null_sink_2_1_0_4_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_2, message_out, virtual_sink_0_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_3, '0', blocks_null_sink_2_2_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_3, '1', blocks_null_sink_2_0_0_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_3, '10', blocks_null_sink_2_1_0_3_0_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_3, '11', blocks_null_sink_2_1_0_2_0_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_3, '12', blocks_null_sink_2_1_0_1_0_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_3, '2', blocks_null_sink_2_1_1_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_3, '3', blocks_null_sink_2_1_0_10_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_3, '4', blocks_null_sink_2_1_0_8_0_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_3, '5', blocks_null_sink_2_1_0_9_0_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_3, '6', blocks_null_sink_2_1_0_7_0_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_3, '7', blocks_null_sink_2_1_0_6_0_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_3, '8', blocks_null_sink_2_1_0_5_0_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_3, '9', blocks_null_sink_2_1_0_4_0_0_0_0, '0']
- [verisure2GFSKRadioChannelToDataMessage_0_3, message_out, virtual_sink_0_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '0', blocks_null_sink_2_2_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '0', qtgui_sink_x_0_1, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '1', blocks_null_sink_2_0_0_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '1', qtgui_time_sink_x_0_0_1_0_0_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '1', qtgui_time_sink_x_0_0_1_0_0_0_2, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '10', blocks_null_sink_2_1_0_3_0_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '10', qtgui_time_sink_x_0_0_0_0_0, '1']
- [verisure4GFSKRadioChannelToDataMessage_0, '11', blocks_null_sink_2_1_0_2_0_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '11', qtgui_time_sink_x_0_0_0_0_0, '2']
- [verisure4GFSKRadioChannelToDataMessage_0, '12', blocks_null_sink_2_1_0_1_0_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '12', qtgui_time_sink_x_0_0_1_0_1, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '13', blocks_null_sink_2_1_0_0_0_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '13', qtgui_time_sink_x_0_0_0_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '14', blocks_add_const_vxx_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '14', blocks_null_sink_2_1_0_1_0_1_0_1, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '2', blocks_null_sink_2_1_0_1_0_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '2', qtgui_time_sink_x_0_0_1_0_0_1_1, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '3', blocks_null_sink_2_1_0_10_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '3', qtgui_time_sink_x_0_0_1_0_0_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '4', blocks_null_sink_2_1_0_8_0_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '4', qtgui_time_sink_x_0_0_1_0_0_2, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '5', blocks_null_sink_2_1_0_9_0_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '5', qtgui_time_sink_x_0_0_0_1, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '6', blocks_null_sink_2_1_0_7_0_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '6', qtgui_time_sink_x_0_0_0_1, '1']
- [verisure4GFSKRadioChannelToDataMessage_0, '7', blocks_null_sink_2_1_0_6_0_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '7', qtgui_number_sink_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '7', qtgui_time_sink_x_0_0_0_1, '2']
- [verisure4GFSKRadioChannelToDataMessage_0, '8', blocks_null_sink_2_1_0_5_0_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '8', qtgui_number_sink_0_0, '1']
- [verisure4GFSKRadioChannelToDataMessage_0, '8', qtgui_time_sink_x_0_0_0_1, '3']
- [verisure4GFSKRadioChannelToDataMessage_0, '9', blocks_null_sink_2_1_0_4_0_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, '9', qtgui_time_sink_x_0_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0, message_out, virtual_sink_0_0_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '0', blocks_null_sink_2_2_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '1', blocks_null_sink_2_0_0_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '10', blocks_null_sink_2_1_0_3_0_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '11', blocks_null_sink_2_1_0_2_0_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '12', blocks_null_sink_2_1_0_1_0_1_0_2, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '13', blocks_null_sink_2_1_0_0_0_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '14', blocks_null_sink_2_1_0_1_0_1_0_1_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '2', blocks_null_sink_2_1_0_1_0_1_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '3', blocks_null_sink_2_1_0_10_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '4', blocks_null_sink_2_1_0_8_0_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '5', blocks_null_sink_2_1_0_9_0_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '6', blocks_null_sink_2_1_0_7_0_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '7', blocks_null_sink_2_1_0_6_0_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '8', blocks_null_sink_2_1_0_5_0_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, '9', blocks_null_sink_2_1_0_4_0_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0, message_out, virtual_sink_0_0_0_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '0', blocks_null_sink_2_2_1_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '1', blocks_null_sink_2_0_0_1_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '10', blocks_null_sink_2_1_0_3_0_1_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '11', blocks_null_sink_2_1_0_2_0_1_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '12', blocks_null_sink_2_1_0_1_0_1_0_2_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '13', blocks_null_sink_2_1_0_0_0_1_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '14', blocks_null_sink_2_1_0_1_0_1_0_1_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '2', blocks_null_sink_2_1_0_1_0_1_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '3', blocks_null_sink_2_1_0_10_1_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '4', blocks_null_sink_2_1_0_8_0_1_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '5', blocks_null_sink_2_1_0_9_0_1_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '6', blocks_null_sink_2_1_0_7_0_1_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '7', blocks_null_sink_2_1_0_6_0_1_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '8', blocks_null_sink_2_1_0_5_0_1_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, '9', blocks_null_sink_2_1_0_4_0_1_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0, message_out, virtual_sink_0_0_0_0_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '0', blocks_null_sink_2_2_1_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '1', blocks_null_sink_2_0_0_1_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '10', blocks_null_sink_2_1_0_3_0_1_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '11', blocks_null_sink_2_1_0_2_0_1_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '12', blocks_null_sink_2_1_0_1_0_1_0_2_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '13', blocks_null_sink_2_1_0_0_0_1_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '14', blocks_null_sink_2_1_0_1_0_1_0_1_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '2', blocks_null_sink_2_1_0_1_0_1_0_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '3', blocks_null_sink_2_1_0_10_1_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '4', blocks_null_sink_2_1_0_8_0_1_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '5', blocks_null_sink_2_1_0_9_0_1_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '6', blocks_null_sink_2_1_0_7_0_1_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '7', blocks_null_sink_2_1_0_6_0_1_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '8', blocks_null_sink_2_1_0_5_0_1_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '9', blocks_null_sink_2_1_0_4_0_1_0_0_0_0, '0']
- [verisure4GFSKRadioChannelToDataMessage_0_0_0_0, message_out, virtual_sink_0_0_0_0_0_0_0_0_0, '0']
- [virtual_source_0, '0', verisure2GFSKRadioChannelToDataMessage_0, '0']
- [virtual_source_0_0, '0', verisure2GFSKRadioChannelToDataMessage_0_0, '0']
- [virtual_source_0_0_0, '0', verisure2GFSKRadioChannelToDataMessage_0_1, '0']
- [virtual_source_0_0_0_0, '0', verisure2GFSKRadioChannelToDataMessage_0_2, '0']
- [virtual_source_0_0_0_0_0, '0', verisure2GFSKRadioChannelToDataMessage_0_3, '0']
- [virtual_source_1, '0', verisure_tcp_server_sink, pdu_in]
- [virtual_source_1_0, '0', verisure_tcp_server_sink, pdu_in]
- [virtual_source_1_1, '0', verisure_tcp_server_sink, pdu_in]
- [virtual_source_1_2, '0', verisure_tcp_server_sink, pdu_in]
- [virtual_source_1_2_0, '0', verisure_tcp_server_sink, pdu_in]
- [virtual_source_1_2_0_0, '0', verisure_tcp_server_sink, pdu_in]
- [virtual_source_1_2_0_1, '0', verisure_tcp_server_sink, pdu_in]
- [virtual_source_1_2_0_2, '0', verisure_tcp_server_sink, pdu_in]
- [virtual_source_1_3, '0', verisure_tcp_server_sink, pdu_in]
- [virtual_source_2, '0', verisure4GFSKRadioChannelToDataMessage_0, '0']
- [virtual_source_2_0, '0', verisure4GFSKRadioChannelToDataMessage_0_0, '0']
- [virtual_source_2_0_0, '0', verisure4GFSKRadioChannelToDataMessage_0_0_0, '0']
- [virtual_source_2_0_0_0, '0', verisure4GFSKRadioChannelToDataMessage_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
