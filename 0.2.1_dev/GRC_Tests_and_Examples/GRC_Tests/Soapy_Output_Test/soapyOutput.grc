options:
  parameters:
    generate_options: qt_gui
    id: soapyOutput
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amp_on
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'True'
    label: RF Amp on (+11 dB aprox)
    pressed: 'True'
    released: 'False'
    type: int
    value: 'True'
  states: {}
- name: antialias_bw
  id: variable_qtgui_chooser
  parameters:
    label: Antialiass Filter Bandwidth
    labels: '["1.75","2.5","3.5","5","5.5","6","7","8","9","10","12","14","15","20","24","28"]'
    num_opts: '0'
    options: '[1.75e6, 2.5e6, 3.5e6, 5e6 ,5.5e6 ,6e6 ,7e6 ,8e6 ,9e6 ,10e6 ,12e6 ,14e6 ,15e6 ,20e6 ,24e6 ,28e6]'
    type: real
    value: 3.5e6
  states: {}
- name: if_gain
  id: variable_qtgui_chooser
  parameters:
    label: IF Gain (0 to 40 dB in 8 dB steps)
    labels: '["0 dB", "+8 dB", "+16 dB","+24 dB","+32 dB","+40 dB"]'
    num_opts: '0'
    options: '[0,8,16,24,32,40]'
    type: int
    value: '16'
  states: {}
- name: lo_osc_freq
  id: variable_qtgui_range
  parameters:
    label: Local Oscillator Frequency
    start: 700e6
    step: 1e3
    stop: 900e6
    value: 869.3e6
  states: {}
- name: lo_osc_freq_err_compensation
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: ADC Sample Rate (1 to 20 Msps in 1 Msps steps)
    start: 1e6
    step: 1e6
    stop: 20e6
    value: 16e6
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    label: LF Gain (0 to 62 dB in 2 dB steps)
    start: '0'
    step: '2'
    stop: '62'
    value: '0'
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: lo_osc_freq
    fftsize: '8192'
    gui_hint: (1,0,1,1)
    name: '"Soapy HW Output Spectrum"'
    rate: '60'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: In Phase (Re)
    label2: Quadrature (Im)
    name: '"Soapy HW Output"'
    size: '96000'
    srate: samp_rate
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.001'
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: soapy_hackrf_source_0_0
  id: soapy_hackrf_source
  parameters:
    amp: amp_on
    bandwidth: antialias_bw
    center_freq: lo_osc_freq+lo_osc_freq_err_compensation
    comment: HackRF
    gain: if_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}

connections:
- [soapy_hackrf_source_0_0, '0', qtgui_sink_x_0_0, '0']
- [soapy_hackrf_source_0_0, '0', qtgui_time_sink_x_0_0_1_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
