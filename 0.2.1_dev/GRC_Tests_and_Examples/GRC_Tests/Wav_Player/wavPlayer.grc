options:
  parameters:
    author: Francisco Nicolás Pérez Fernández
    generate_options: no_gui
    id: wavPlayer
    output_language: python
    title: Wav Player
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: pmt.make_dict()
    file: C:\Users\fnpfa\Repositories\CSD\sniffer\GRC Tests and Examples\GRC Tests\Spectrum Recorder\Recording1.complexRecording
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    detached: 'False'
    file: C:\Users\fnpfa\Repositories\CSD\sniffer\GRC Tests and Examples\GRC Tests\Spectrum Recorder\Recording1.complexRecording
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\fnpfa\Repositories\CSD\sniffer\GRC Tests and Examples\GRC Tests\Spectrum Recorder\Recording1.complexRecording
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\fnpfa\Repositories\CSD\sniffer\GRC Tests and Examples\GRC Tests\Spectrum Recorder\Recording1.complexRecording
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/fnpfar/repositories/git/csd/sniffer/GRC Tests and Examples/GRC Tests/Spectrum Recorder/test.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(samp_rate)
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/fnpfar/repositories/git/csd/sniffer/GRC_Tests_and_Examples/GRC Tests/Wav Player/NEWKM100_160.wav
    repeat: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    gui_hint: (1,0,1,1)
    name: '"Osmocom/Soapy HW Output Spectrum"'
    rate: '60'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: In Phase (Re)
    label2: Quadrature (Im)
    name: '"Osmocom/Soapy HW Output"'
    size: '96000'
    srate: samp_rate
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.001'
    ymax: '1.2'
    ymin: '-1.2'
  states: {state: disabled}

connections:
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_file_meta_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle_0, '0', blocks_file_meta_sink_0, '0']
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0_1_0_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
