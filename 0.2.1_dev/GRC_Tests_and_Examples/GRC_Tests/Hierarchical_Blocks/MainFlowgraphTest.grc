options:
  parameters:
    author: Francisco Nicolás Pérez Fernández
    description: A test flowgraph for hierarchical blocks
    generate_options: qt_gui
    id: MainFlowgraphTest
    output_language: python
    title: Main
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '160000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '2000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 3e3
    low_cutoff_freq: 1e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channelModelTest1_0
  id: channelModelTest1
  parameters:
    attenuationDecibels: '5'
    delaySeconds: '5e-3'
    noiseStandardDeviation: '10e-1'
    samp_rate: samp_rate
  states: {}
- name: channelModelTest1_0_0
  id: channelModelTest1
  parameters:
    attenuationDecibels: '10'
    delaySeconds: '5e-3'
    noiseStandardDeviation: '5'
    samp_rate: samp_rate
  states: {}
- name: channelModelTest1_0_0_0
  id: channelModelTest1
  parameters:
    attenuationDecibels: '10'
    delaySeconds: '5e-3'
    noiseStandardDeviation: '5'
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    rate: '10000'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    rate: '10000'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    rate: '10000'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.0001'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [band_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', channelModelTest1_0, '0']
- [blocks_throttle_0, '0', channelModelTest1_0_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '1']
- [channelModelTest1_0, '0', band_pass_filter_0, '0']
- [channelModelTest1_0, '0', qtgui_sink_x_0_0, '0']
- [channelModelTest1_0_0, '0', channelModelTest1_0_0_0, '0']
- [channelModelTest1_0_0_0, '0', qtgui_sink_x_0_0_0, '0']

metadata:
  file_format: 1
