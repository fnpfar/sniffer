options:
  parameters:
    author: Francisco Nicolás Pérez Fernández
    generate_options: hb
    id: channelModelTest1
    output_language: python
    title: Channel Model Test 1
  states: {}

blocks:
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noiseStandardDeviation
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: complex
  states: {}
- name: attenuationDecibels
  id: parameter
  parameters:
    label: Attenuation (dB)
    value: '5'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(samp_rate*delaySeconds)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-attenuationDecibels/20)
    type: complex
  states: {}
- name: delaySeconds
  id: parameter
  parameters:
    label: Delay (s)
    value: '5e-3'
  states: {}
- name: noiseStandardDeviation
  id: parameter
  parameters:
    label: Noise Standard Deviation
    value: '10e-1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    value: '32000'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0, '0', pad_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_0, '0']
- [pad_source_0, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
