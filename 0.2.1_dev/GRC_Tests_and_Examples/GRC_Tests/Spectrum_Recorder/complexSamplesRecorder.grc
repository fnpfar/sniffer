options:
  parameters:
    author: Francisco Nicolás Pérez Fernández
    generate_options: qt_gui
    id: complexSamplesRecorder
    output_language: python
    title: Spectrum Recorder
  states: {}

blocks:
- name: amp_on
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'True'
    label: RF Amp on (+11 dB aprox)
    pressed: 'True'
    released: 'False'
    type: int
    value: 'True'
  states: {}
- name: antialias_bw
  id: variable_qtgui_chooser
  parameters:
    label: Antialiass Filter Bandwidth
    labels: '["1.75","2.5","3.5","5","5.5","6","7","8","9","10","12","14","15","20","24","28"]'
    num_opts: '0'
    options: '[1.75e6, 2.5e6, 3.5e6, 5e6 ,5.5e6 ,6e6 ,7e6 ,8e6 ,9e6 ,10e6 ,12e6 ,14e6 ,15e6 ,20e6 ,24e6 ,28e6]'
    type: real
    value: 3.5e6
  states: {}
- name: if_gain
  id: variable_qtgui_chooser
  parameters:
    label: IF Gain (0 to 40 dB in 8 dB steps)
    labels: '["0 dB", "+8 dB", "+16 dB","+24 dB","+32 dB","+40 dB"]'
    num_opts: '0'
    options: '[0,8,16,24,32,40]'
    type: int
    value: '16'
  states: {}
- name: lo_osc_freq
  id: variable_qtgui_range
  parameters:
    label: Local Oscillator Frequency
    start: 700e6
    step: 1e3
    stop: 900e6
    value: 869.3e6
  states: {}
- name: lo_osc_freq_err_compensation
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: ADC Sample Rate (1 to 20 Msps in 1 Msps steps)
    start: 1e6
    step: 1e6
    stop: 20e6
    value: 16e6
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    label: LF Gain (0 to 62 dB in 2 dB steps)
    start: '0'
    step: '2'
    stop: '62'
    value: '0'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: pmt.make_dict()
    file: C:\Users\fnpfa\Repositories\CSD\sniffer\GRC Tests and Examples\GRC Tests\Spectrum Recorder\Recording1.complexRecording
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    detached: 'False'
    file: C:\Users\fnpfa\Repositories\CSD\sniffer\GRC Tests and Examples\GRC Tests\Spectrum Recorder\Recording1.complexRecording
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\fnpfa\Repositories\CSD\sniffer\GRC Tests and Examples\GRC Tests\Spectrum Recorder\Recording1.complexRecording
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\fnpfa\Repositories\CSD\sniffer\GRC Tests and Examples\GRC Tests\Spectrum Recorder\Recording1.complexRecording
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '3'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\Users\fnpfa\Desktop\spectrumRecord.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(samp_rate)
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\fnpfa\Desktop\spectrumRecord1.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    bb_gain0: vga_gain
    bw0: antialias_bw
    freq0: lo_osc_freq+lo_osc_freq_err_compensation
    gain0: 11 if amp_on else 0
    gain_mode0: 'False'
    if_gain0: if_gain
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: lo_osc_freq
    fftsize: '8192'
    gui_hint: (1,0,1,1)
    name: '"Osmocom/Soapy HW Output Spectrum"'
    rate: '60'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: In Phase (Re)
    label2: Quadrature (Im)
    name: '"Osmocom/Soapy HW Output"'
    size: '96000'
    srate: samp_rate
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.001'
    ymax: '1.2'
    ymin: '-1.2'
  states: {state: disabled}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: lo_osc_freq+lo_osc_freq_err_compensation
    comment: TX
    samp_rate: samp_rate
    type: fc32
    vga: '20'
  states: {state: disabled}
- name: soapy_hackrf_source_0_0
  id: soapy_hackrf_source
  parameters:
    amp: amp_on
    bandwidth: antialias_bw
    center_freq: lo_osc_freq+lo_osc_freq_err_compensation
    comment: RX
    gain: if_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_file_meta_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle_0, '0', blocks_file_meta_sink_0, '0']
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0_1_0_0_0_0, '0']
- [blocks_throttle_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [osmosdr_source_0_0, '0', blocks_complex_to_float_0, '0']
- [osmosdr_source_0_0, '0', blocks_file_meta_sink_0, '0']
- [osmosdr_source_0_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0_0, '0', qtgui_sink_x_0_0, '0']
- [osmosdr_source_0_0, '0', qtgui_time_sink_x_0_0_1_0_0_0_0, '0']
- [osmosdr_source_0_0, '0', soapy_hackrf_sink_0, '0']
- [soapy_hackrf_source_0_0, '0', blocks_complex_to_float_0, '0']
- [soapy_hackrf_source_0_0, '0', blocks_file_meta_sink_0, '0']
- [soapy_hackrf_source_0_0, '0', blocks_file_sink_0, '0']
- [soapy_hackrf_source_0_0, '0', qtgui_sink_x_0_0, '0']
- [soapy_hackrf_source_0_0, '0', qtgui_time_sink_x_0_0_1_0_0_0_0, '0']
- [soapy_hackrf_source_0_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
