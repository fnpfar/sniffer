options:
  parameters:
    author: Francisco Nicolás Pérez Fernández
    generate_options: qt_gui
    id: hwAntialiassFilterMeasurement
    output_language: python
    title: HW LF Antialiass Filter Measurement Test
  states: {}

blocks:
- name: amp_on
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'True'
    label: RF Amp on (+11 dB aprox)
    pressed: 'True'
    released: 'False'
    type: int
    value: 'True'
  states: {}
- name: antialias_bw
  id: variable_qtgui_chooser
  parameters:
    label: Antialiass Filter Bandwidth
    labels: '["1.75","2.5","3.5","5","5.5","6","7","8","9","10","12","14","15","20","24","28"]'
    num_opts: '0'
    options: '[1.75e6, 2.5e6, 3.5e6, 5e6 ,5.5e6 ,6e6 ,7e6 ,8e6 ,9e6 ,10e6 ,12e6 ,14e6 ,15e6 ,20e6 ,24e6 ,28e6]'
    type: real
    value: 3.5e6
  states: {}
- name: if_gain
  id: variable_qtgui_chooser
  parameters:
    label: IF Gain (0 to 40 dB in 8 dB steps)
    labels: '["0 dB", "+8 dB", "+16 dB","+24 dB","+32 dB","+40 dB"]'
    num_opts: '0'
    options: '[0,8,16,24,32,40]'
    type: int
    value: '0'
  states: {}
- name: lo_osc_freq
  id: variable_qtgui_range
  parameters:
    label: Local Oscillator Frequency
    start: 700e6
    step: 1e3
    stop: 900e6
    value: 869.3e6
  states: {}
- name: lo_osc_freq_err_compensation
  id: variable
  parameters:
    value: 14e3
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: ADC Sample Rate (1 to 20 Msps in 1 Msps steps)
    start: 1e6
    step: 1e6
    stop: 20e6
    value: 13e6
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    label: LF Gain (0 to 62 dB in 2 dB steps)
    start: '0'
    step: '2'
    stop: '62'
    value: '0'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: vga_gain
    bw0: antialias_bw
    freq0: lo_osc_freq+lo_osc_freq_err_compensation
    gain0: 11 if amp_on else 0
    gain_mode0: 'False'
    if_gain0: if_gain
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: lo_osc_freq
    fftsize: '8192'
    gui_hint: (1,0,1,1)
    name: '"Osmocom/Soapy HW Output Spectrum"'
    rate: '60'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '4096'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.001'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: amp_on
    bandwidth: antialias_bw
    center_freq: lo_osc_freq+lo_osc_freq_err_compensation
    gain: if_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_sink_x_0_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_sink_x_0_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
