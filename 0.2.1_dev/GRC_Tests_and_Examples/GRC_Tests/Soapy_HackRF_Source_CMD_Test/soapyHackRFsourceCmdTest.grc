options:
  parameters:
    author: Francisco Nicolás Pérez Fernández
    comment: |-
      Conclusion:
       Seems that the message 
      keys in the documentation for the
      Soapy Source have no effect in
      changing the parameters.
    generate_options: qt_gui
    id: soapyHackRFsourceCmdTest
    output_language: python
    title: Soapy HackRF Source Commands test
  states: {}

blocks:
- name: antialiass_filter_bw0
  id: variable
  parameters:
    value: 3.5e6
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: 850e6
    step: '1'
    stop: 870e6
    value: 869.3e6
  states: {}
- name: center_freq0
  id: variable
  parameters:
    value: 869.3e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: if_gain0
  id: variable
  parameters:
    value: '16'
  states: {}
- name: lna_on0
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: qtgui_msgdigitalnumbercontrol_0
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    maxFreqHz: 1700e6
    minFreqHz: 30e6
    value: 100e6
  states: {}
- name: rate
  id: variable_qtgui_range
  parameters:
    start: '1000000'
    step: '1'
    stop: '16000000'
    value: '13000000'
  states: {}
- name: samp_rate0
  id: variable
  parameters:
    value: '13000000'
  states: {}
- name: vga_gain0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: center_freq
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: gain
    target: gain
  states: {}
- name: blocks_var_to_msg_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: rate
    target: rate
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate0
    fc: center_freq0
    fftsize: '8192'
    gui_hint: (1,0,1,1)
    name: '"Osmocom/Soapy HW Output Spectrum"'
    rate: '60'
    showrf: 'True'
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: lna_on0
    bandwidth: antialiass_filter_bw0
    center_freq: center_freq0
    comment: HackRF
    gain: if_gain0
    samp_rate: samp_rate0
    type: fc32
    vga: vga_gain0
  states: {}

connections:
- [blocks_var_to_msg_0, msgout, qtgui_msgdigitalnumbercontrol_0, valuein]
- [blocks_var_to_msg_0, msgout, soapy_hackrf_source_0, cmd]
- [blocks_var_to_msg_0_0, msgout, soapy_hackrf_source_0, cmd]
- [blocks_var_to_msg_0_0_0, msgout, soapy_hackrf_source_0, cmd]
- [soapy_hackrf_source_0, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
